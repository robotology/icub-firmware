# Keil uVision project eom-eappbasic-full.uvproj, settings and files
target mcbstm32c-zerooffset (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: udpnode +hex
  c flags: Optim=4 oTime=1
  c define: SHALS_MODE_STATIC EENV_EAPPLICATION_FORCE_CODE_OFFSET_TO_ZERO _FORCE_NETWORK_FROM_IPAL_CFG HAL_USE_ARCH_ARM
  c misc: --c99
  c include: ..\abslayer-cfg;..\app_basic;..\..\..\..\sys\abs\api;..\..\..\..\sys\env\api;..\app_extra;..\..\..\..\sys\mid\api;..\..\..\..\..\porting;..\..\..\..\..\any-arch\body\embenv\envcom;..\..\..\..\..\any-arch\sys\embobj\core\api;..\..\..\..\..\any-arch\sys\embobj\core\src;..\..\..\..\..\any-arch\sys\embobj\core-mee\api;..\..\..\..\..\any-arch\sys\embobj\core-mee\src;..\..\..\..\..\any-arch\sys\embobj\env\api;..\..\..\..\..\any-arch\sys\embobj\env\src;..\..\..\..\..\any-arch\sys\embobj\ipnet\api;..\..\..\..\..\any-arch\sys\embobj\ipnet\src;..\..\..\..\..\any-arch\sys\embobj\ipnet-mee\api;..\..\..\..\..\any-arch\sys\embobj\ipnet-mee\src;.;..\..\..\..\..\any-arch\sys\embobj\core-vee\api;..\..\..\..\..\any-arch\sys\embobj\core-vee\src
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\eApplication-zerooffset.sct
  group app_basic
    ../app_basic/: eom_applbasic_main.c eom_applbasic_info.c eom_applbasic_specialise.c
    ../app_extra/: eom_applbasic_extra.c
  group abslayer-lib
    ../../../../sys/abs/lib/: osal.cm3.lib hal.stm32f1.mcbstm32c.lib hal.stm32f1.ems001.lib ipal.base.medium.lib osal.cm3.dbg.lib
    ../../../../sys/abs/src/: hal_stm32f1_startup.s
  group abslayer-cfg
    ../abslayer-cfg/: hal_cfg.c ipal_cfg.c osal_cfg.c hal_cfg.h ipal_cfg.h osal_cfg.h
  group eo-core
    ../../../../../any-arch/sys/embobj/core/src/: EOaction.c EOarray.c EoCommon.c EOconstarray.c EOconstvector.c EOdeque.c EOfifo.c EOfifoByte.c EOfifoWord.c EOlist.c EOtheErrorManager.c EOtheMemoryPool.c EOtimer.c EOvector.c
    ../../../../../any-arch/sys/embobj/core-vee/src/: EOVmutex.c EOVtask.c EOVtheCallbackManager.c EOVtheSystem.c EOVtheTimerManager.c
  group eo-mee
    ../../../../../any-arch/sys/embobj/core-mee/src/: EOMmutex.c EOMtask.c EOMtheCallbackManager.c EOMtheSystem.c EOMtheTimerManager.c
  group eo-ipnet
    ../../../../../any-arch/sys/embobj/ipnet-mee/src/: EOMtheIPnet.c
    ../../../../../any-arch/sys/embobj/ipnet/src/: EOpacket.c EOsocket.c EOsocketDatagram.c EOVtheIPnet.c
  group eo-arm-env
    ../../../../../any-arch/sys/embobj/env/src/: EOtheARMenvironment.c EOVtheEnvironment.c
    ../../../../../any-arch/body/embenv/envcom/: eEcommon.c
    ../../../../sys/env/src/: shalBASE.c shalINFO.c shalPART.c
  group eventviewer
    ../../../../sys/mid/lib/: eventviewer.cm3.lib
target ems001-zerooffset (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: udpnode +hex
  c flags: Optim=1
  c define: as above
  c misc: --c99
  c include: ..\abslayer-cfg;..\app;..\..\..\..\embobj\embobj\embobj-api;..\..\..\..\embobj\embobj\embobj-src;..\..\..\..\embobj\embobj\embobj-cfg;..\..\..\..\..\sys\abs\api;..\..\..\..\..\sys\env\api;..\..\..\..\..\sys\prt;..\app_extra;..\..\..\..\..\sys\mid\api;..\app_basic
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\eApplication-zerooffset.sct
