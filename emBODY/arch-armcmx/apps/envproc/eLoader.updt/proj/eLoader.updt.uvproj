# Keil uVision project eLoader.updt.uvproj, settings and files
target mcbstm32c-hal.lib (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: eLoader.updt +hex
  c flags: Optim=1 OneElfS=1
  c define: HAL_USE_ARCH_ARM SHALS_MODE_STATIC BOARD_MCBSTM32C ENABLE_USER_INPUT ENABLE_ERASE_EEPROM
  c misc: --c99
  c include: ..\..\..\..\sys\abs\api;..\..\..\..\sys\env\api;..\..\..\..\..\any-arch\body\embenv\envcom;..\..\..\..\..\porting;..\..\..\..\sys\env\api
  asm misc: --cpreproc
  asm include: ..\app
  memory RVCT4: ROM 0x8000000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\eLoader.sct
  group application
    ../app/: loader_updt.c
  group arm-shalib-src
    ../../../../sys/env/src/: shalBASE.c shalINFO.c shalPART.c
  group hal
    ../app/: hal_cfg.h hal_cfg.c
    ../../../../sys/abs/lib/: hal.stm32f1.ems001.lib hal.stm32f1.mcbstm32c.lib
    ../../../../sys/abs/src/: hal_stm32f1_startup.s
  group any-common
    ../../../../../any-arch/body/embenv/envcom/: eEcommon.c
target ems001-hal.lib (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: eLoader +hex
  c flags: Optim=4 oTime=1 OneElfS=1
  c define: HAL_USE_ARCH_ARM SHALS_MODE_STATIC BOARD_EMS001
  c misc: --c99
  c include: ..\..\..\..\sys\abs\api;..\..\..\..\sys\env\api;..\..\..\..\..\any-arch\body\embenv\envcom;..\..\..\..\..\porting
  asm misc: --cpreproc
  asm include: ..\app
  memory RVCT4: ROM 0x8000000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\eLoader.sct
