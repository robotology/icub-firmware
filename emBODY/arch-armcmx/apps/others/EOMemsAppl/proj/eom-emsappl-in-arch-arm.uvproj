# Keil uVision project eom-emsappl-in-arch-arm.uvproj, settings and files
target emsappl-mcbstm32c-zerooffset (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: emsappl4mcbstm32c +hex
  c flags: Optim=1 oTime=1
  c define: HAL_USE_ARCH_ARM SHALS_MODE_STATIC EENV_EAPPLICATION_FORCE_CODE_OFFSET_TO_ZERO
  c misc: --c99
  c include: ..\abslayer-cfg;..\app_basic;..\..\..\..\sys\abs\api;..\..\..\..\sys\env\api;..\app_extra;..\..\..\..\sys\mid\api;..\..\..\..\..\porting;..\..\..\..\..\any-arch\body\embenv\envcom;..\..\..\..\..\any-arch\sys\embobj\core\api;..\..\..\..\..\any-arch\sys\embobj\core\src;..\..\..\..\..\any-arch\sys\embobj\core-mee\api;..\..\..\..\..\any-arch\sys\embobj\core-mee\src;..\..\..\..\..\any-arch\sys\embobj\env\api;..\..\..\..\..\any-arch\sys\embobj\env\src;..\..\..\..\..\any-arch\sys\embobj\ipnet\api;..\..\..\..\..\any-arch\sys\embobj\ipnet\src;..\..\..\..\..\any-arch\sys\embobj\ipnet-mee\api;..\..\..\..\..\any-arch\sys\embobj\ipnet-mee\src;.;..\..\..\..\..\any-arch\sys\embobj\core-vee\api;..\..\..\..\..\any-arch\sys\embobj\core-vee\src;..\..\..\..\..\any-arch\sys\embobj\prot\src;..\..\..\..\..\any-arch\sys\embobj\prot\api;..\..\..\..\..\any-arch\sys\embobj\icub\api;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\board-eps;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-management\api;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-management\src;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-motioncontrol\api;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-motioncontrol\src;..\..\..\..\body\embobj\embobj\embobj-icub\icub-ems;..\..\..\..\..\any-arch\sys\embobj\utils\api;..\..\..\..\..\any-arch\sys\embobj\utils\src;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-analogsensors\api;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-analogsensors\src;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-skin\api;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-skin\src
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\eApplication-zerooffset.sct
  group app_main
    ../app_main/: eom_emsappl_main.c
  group abslayer-lib
    ../../../../sys/abs/lib/: osal.cm3.lib osal.cm3.dbg.lib hal.stm32f1.mcbstm32c.lib hal.stm32f1.ems001.lib ipal.base.medium.lib
    ../../../../sys/abs/src/: hal_stm32f1_startup.s
  group abslayer-cfg
    ../abslayer-cfg/: hal_cfg.c ipal_cfg.c osal_cfg.c hal_cfg.h ipal_cfg.h osal_cfg.h
  group eo-core
    ../../../../../any-arch/sys/embobj/core/src/: EOaction.c EOarray.c EoCommon.c EOconstarray.c EOconstvector.c EOdeque.c EOfifo.c EOfifoByte.c EOfifoWord.c EOlist.c EOtheErrorManager.c EOtheMemoryPool.c EOtimer.c EOvector.c
    ../../../../../any-arch/sys/embobj/core-vee/src/: EOVmutex.c EOVtask.c EOVtheCallbackManager.c EOVtheSystem.c EOVtheTimerManager.c
  group eo-mee
    ../../../../../any-arch/sys/embobj/core-mee/src/: EOMmutex.c EOMtask.c EOMtheCallbackManager.c EOMtheSystem.c EOMtheTimerManager.c
  group eo-ipnet
    ../../../../../any-arch/sys/embobj/ipnet-mee/src/: EOMtheIPnet.c
    ../../../../../any-arch/sys/embobj/ipnet/src/: EOpacket.c EOsocket.c EOsocketDatagram.c EOVtheIPnet.c
  group eo-arm-env
    ../../../../../any-arch/sys/embobj/env/src/: EOtheARMenvironment.c EOVtheEnvironment.c
    ../../../../../any-arch/body/embenv/envcom/: eEcommon.c
    ../../../../sys/env/src/: shalBASE.c shalINFO.c shalPART.c
  group eo-nvs-common
    ../../../../../any-arch/sys/embobj/prot/src/: EOmatrix3d.c EOnv.c EOnvsCfg.c EOreceiver.c EOrop.c EOropframe.c EOstorageEEPROM.c EOtheAgent.c EOtheFormer.c EOtheParser.c EOtransceiver.c EOtransmitter.c EOtreenode.c EOVstorage.c
  group eo-nvs-board
    ../../../../../any-arch/sys/embobj/prot/src/: EOtheBOARDtransceiver.c
  group eo-nvs-cfg-board
    ../../../../../any-arch/sys/embobj/icub-nvscfg/board-eps/: eOcfg_EPs_eb1.c eOcfg_EPs_eb2.c eOcfg_EPs_eb3.c eOcfg_EPs_eb4.c eOcfg_EPs_eb5.c eOcfg_EPs_eb6.c eOcfg_EPs_eb7.c eOcfg_EPs_eb8.c eOcfg_EPs_eb9.c
  group eo-nvs-cfg-ep-mn-any
    ../../../../../any-arch/sys/embobj/icub-nvscfg/ep-management/src/: eOcfg_nvsEP_mn.c
  group eo-nvs-cfg-mn-endpoints
    ../../../../../any-arch/sys/embobj/icub-nvscfg/ep-management/src/: eOcfg_nvsEP_mn_appl_con.c eOcfg_nvsEP_mn_appl_usr.c eOcfg_nvsEP_mn_comm_con.c eOcfg_nvsEP_mn_comm_usr.c
  group eo-nvs-cfg-mc-any
    ../../../../../any-arch/sys/embobj/icub-nvscfg/ep-motioncontrol/src/: eOcfg_nvsEP_mc.c eOcfg_nvsEP_mc_any_con_bodypart.c eOcfg_nvsEP_mc_any_con_jxx.c eOcfg_nvsEP_mc_any_con_jxxdefault.c eOcfg_nvsEP_mc_any_con_mxx.c eOcfg_nvsEP_mc_any_con_mxxdefault.c eOcfg_nvsEP_mc_any_con_cxx.c eOcfg_nvsEP_mc_any_con_cxxdefault.c
  group eo-nvs-cfg-mc-endpoints
    ../../../../../any-arch/sys/embobj/icub-nvscfg/ep-motioncontrol/src/: eOcfg_nvsEP_mc_lowerarm_con.c eOcfg_nvsEP_mc_lowerarm_usr.c eOcfg_nvsEP_mc_lowerleg_con.c eOcfg_nvsEP_mc_lowerleg_usr.c eOcfg_nvsEP_mc_torso_con.c eOcfg_nvsEP_mc_torso_usr.c eOcfg_nvsEP_mc_upperarm_con.c eOcfg_nvsEP_mc_upperarm_usr.c eOcfg_nvsEP_mc_upperleg_con.c eOcfg_nvsEP_mc_upperleg_usr.c
  group eo-nvs-cfg-as-any
    ../../../../../any-arch/sys/embobj/icub-nvscfg/ep-analogsensors/src/: eOcfg_nvsEP_as.c eOcfg_nvsEP_as_any_con_body.c eOcfg_nvsEP_as_any_con_mxx.c eOcfg_nvsEP_as_any_con_mxxdefault.c eOcfg_nvsEP_as_any_con_sxx.c eOcfg_nvsEP_as_any_con_sxxdefault.c
  group eo-nvs-cfg-as-endpoints
    ../../../../../any-arch/sys/embobj/icub-nvscfg/ep-analogsensors/src/: eOcfg_nvsEP_as_onemais_con.c eOcfg_nvsEP_as_onemais_usr.c eOcfg_nvsEP_as_onestrain_con.c eOcfg_nvsEP_as_onestrain_usr.c
  group eo-nvs-cfg-sk-any
    ../../../../../any-arch/sys/embobj/icub-nvscfg/ep-skin/src/: eOcfg_nvsEP_sk.c
  group eo-nvs-cfg-skin-endpoints
    ../../../../../any-arch/sys/embobj/icub-nvscfg/ep-skin/src/: eOcfg_nvsEP_sk_emsboard_con.c eOcfg_nvsEP_sk_emsboard_usr.c
  group eo-nvs-cfg-usrcbk
    ../../../../body/embobj/embobj/embobj-icub/icub-nvscfg/ep-management/usrcbk/: eOcfg_nvsEP_mn_comm_usrcbk_ebx.c
  group eo-sm
    ../../../../../any-arch/sys/embobj/utils/src/: EOsm.c
  group icub-ems
    ../../../../body/embobj/embobj/embobj-icub/icub-ems/: eOcfg_sm_EMSappl.c EOMtheEMSappl.c EOMtheEMSsocket.c EOMtheEMStransceiver.c EOMtheEMSconfigurator.c EOMtheEMSerror.c EOMtheEMSrunner.c EOMtheEMSapplCfg.c EOMtheEMSdiscoverylistener.c EOMtheEMSdiscoverytransceiver.c appl-core.c
  group eventviewer
    ../../../../sys/mid/lib/: eventviewer.cm3.lib
  group icub-ems-cfg
    ../../../../body/embobj/embobj/embobj-icub/icub-ems/: EOMtheEMSapplCfg_cfg.h overridden_configurator.c overridden_runner.c overridden_appl.c overridden_error.c
target emsappl-mcbstm32c-normoffset (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: emsappl4mcbstm32c +hex
  c flags: Optim=1 OneElfS=1
  c define: HAL_USE_ARCH_ARM SHALS_MODE_STATIC _FORCE_NETWORK_FROM_IPAL_CFG
  c misc: --c99
  c include: as above
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\eApplication.sct
target emsappl-ems001brd-normoffset (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: emsappl4mcbstm32c +hex
  c flags: Optim=1
  c define: HAL_USE_ARCH_ARM SHALS_MODE_STATIC
  c misc: --c99
  c include: as above
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\eApplication.sct
target emsappl-ems001brd-zerooffset (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: emsappl4mcbstm32c +hex
  c flags: Optim=1
  c define: HAL_USE_ARCH_ARM SHALS_MODE_STATIC EENV_EAPPLICATION_FORCE_CODE_OFFSET_TO_ZERO _FORCE_NETWORK_FROM_IPAL_CFG
  c misc: --c99
  c include: as above
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\eApplication-zerooffset.sct
