# Keil uVision project eom-emsappl-wip1.uvproj, settings and files
target emsappl-mcbstm32c-zerooffset (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: emsappl4mcbstm32c +hex
  c flags: Optim=1 wLevel=2
  c define: EMSAPPL_USE_CORE HAL_USE_ARCH_ARM SHALS_MODE_STATIC EENV_EAPPLICATION_FORCE_CODE_OFFSET_TO_ZERO
  c misc: --c99
  c include: .;..\app_main;..\app_cfg;..\abslayer-cfg;..\..\..\..\sys\abs\api;..\..\..\..\sys\env\api;..\..\..\..\sys\mid\api;..\..\..\..\..\porting;..\..\..\..\..\any-arch\body\embenv\envcom;..\..\..\..\..\any-arch\sys\embobj\core\api;..\..\..\..\..\any-arch\sys\embobj\core\src;..\..\..\..\..\any-arch\sys\embobj\core-mee\api;..\..\..\..\..\any-arch\sys\embobj\core-mee\src;..\..\..\..\..\any-arch\sys\embobj\env\api;..\..\..\..\..\any-arch\sys\embobj\env\src;..\..\..\..\..\any-arch\sys\embobj\ipnet\api;..\..\..\..\..\any-arch\sys\embobj\ipnet\src;..\..\..\..\..\any-arch\sys\embobj\ipnet-mee\api;..\..\..\..\..\any-arch\sys\embobj\ipnet-mee\src;..\..\..\..\..\any-arch\sys\embobj\core-vee\api;..\..\..\..\..\any-arch\sys\embobj\core-vee\src;..\..\..\..\..\any-arch\sys\embobj\wip-prot\src;..\..\..\..\..\any-arch\sys\embobj\wip-prot\api;..\..\..\..\..\any-arch\sys\embobj\wip-icub\api;..\..\..\..\..\any-arch\sys\embobj\wip-icub-nvscfg;..\..\..\..\..\any-arch\sys\embobj\utils\api;..\..\..\..\..\any-arch\sys\embobj\utils\src;..\..\..\..\..\any-arch\sys\embobj\wip-icub-app\api;..\..\..\..\..\any-arch\sys\embobj\wip-icub-app\src;..\..\..\..\..\any-arch\sys\embobj\wip-icub-prot\api;..\..\..\..\..\any-arch\sys\embobj\wip-icub-prot\src; ..\..\..\..\..\any-arch\sys\embobj\wip-icub-prot\cfg
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\eApplication-zerooffset.sct
  group app_main
    ../app_main/: eom_emsappl_main.c
  group abslayer-lib
    ../../../../sys/abs/lib/: osal.cm3.lib osal.cm3.dbg.lib hal.stm32f1.mcbstm32c.lib hal.stm32f1.ems001.lib ipal.base.medium.lib
    ../../../../sys/abs/src/: hal_stm32f1_startup.s
  group abslayer-cfg
    ../abslayer-cfg/: hal_cfg.c ipal_cfg.c osal_cfg.c hal_cfg.h ipal_cfg.h osal_cfg.h
  group eo-core
    ../../../../../any-arch/sys/embobj/core/src/: EOaction.c EOarray.c EoCommon.c EOconstarray.c EOconstvector.c EOdeque.c EOfifo.c EOfifoByte.c EOfifoWord.c EOlist.c EOtheErrorManager.c EOtheMemoryPool.c EOtimer.c EOvector.c
    ../../../../../any-arch/sys/embobj/core-vee/src/: EOVmutex.c EOVtask.c EOVtheCallbackManager.c EOVtheSystem.c EOVtheTimerManager.c
  group eo-mee
    ../../../../../any-arch/sys/embobj/core-mee/src/: EOMmutex.c EOMtask.c EOMtheCallbackManager.c EOMtheSystem.c EOMtheTimerManager.c
  group eo-ipnet
    ../../../../../any-arch/sys/embobj/ipnet-mee/src/: EOMtheIPnet.c
    ../../../../../any-arch/sys/embobj/ipnet/src/: EOpacket.c EOsocket.c EOsocketDatagram.c EOVtheIPnet.c
  group eo-arm-env
    ../../../../../any-arch/sys/embobj/env/src/: EOtheARMenvironment.c EOVtheEnvironment.c
    ../../../../../any-arch/body/embenv/envcom/: eEcommon.c
    ../../../../sys/env/src/: shalBASE.c shalINFO.c shalPART.c
  group eo-comm
    ../../../../../any-arch/sys/embobj/wip-prot/src/: EOconfirmationManager.c EOnv.c EOreceiver.c EOrop.c EOropframe.c EOtheAgent.c EOtheFormer.c EOtheParser.c EOtransceiver.c EOtransmitter.c EOnvSet.c
  group eo-comm-board
    ../../../../../any-arch/sys/embobj/wip-prot/src/: EOtheBOARDtransceiver.c
  group eo-nvs-cfg-board
    ../../../../../any-arch/sys/embobj/wip-icub-nvscfg/: eOprot_b01.c eOprot_b02.c
  group protocol
    ../../../../../any-arch/sys/embobj/wip-icub-prot/src/: EoProtocol.c EoProtocolEPs.c
  group protocol-as
    ../../../../../any-arch/sys/embobj/wip-icub-prot/src/: EoProtocolAS_fun.c EoProtocolAS_rom.c
  group protocol-mc
    ../../../../../any-arch/sys/embobj/wip-icub-prot/src/: EoProtocolMC_fun.c EoProtocolMC_rom.c
  group protocol-mn
    ../../../../../any-arch/sys/embobj/wip-icub-prot/src/: EoProtocolMN_fun.c EoProtocolMN_rom.c
  group protocol-sk
    ../../../../../any-arch/sys/embobj/wip-icub-prot/src/: EoProtocolSK_fun.c EoProtocolSK_rom.c
  group eo-nvs-cfg-usrcbk
    ../app_cfg/: EoProtocolEPmn_fun_overridden.c
  group eo-sm
    ../../../../../any-arch/sys/embobj/utils/src/: EOsm.c
  group icub-ems
    ../../../../../any-arch/sys/embobj/wip-icub-app/src/: eOcfg_sm_EMSappl.c EOMtheEMSappl.c EOMtheEMSapplCfg.c EOMtheEMSconfigurator.c EOMtheEMSerror.c EOMtheEMSrunner.c EOMtheEMSsocket.c EOMtheEMStransceiver.c EOMtheEMSdiscoverylistener.c EOMtheEMSdiscoverytransceiver.c OPCprotocolManager.c EOMtheEMSbackdoor.c EOMtheEMSbackdoortransceiver.c
  group eventviewer
    ../../../../sys/mid/lib/: eventviewer.cm3.lib
  group icub-ems-cfg
    ../app_cfg/: EOMtheEMSapplCfg_cfg.h example_overridden_appl.c example_overridden_configurator.c example_overridden_error.c example_overridden_runner.c overridden_backdoortransceiver.c OPCprotocolManager_Cfg.c
  group host-transceiver
    ../../../../../any-arch/sys/embobj/wip-prot/src/: EOhostTransceiver.c
target emsappl-mcbstm32c-normoffset (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: emsappl4mcbstm32c +hex
  c flags: Optim=1 OneElfS=1
  c define: EMSAPPL_USE_CORE HAL_USE_ARCH_ARM SHALS_MODE_STATIC _FORCE_NETWORK_FROM_IPAL_CFG
  c misc: --c99
  c include: ..\abslayer-cfg;..\app_main;..\app_cfg;..\..\..\..\sys\abs\api;..\..\..\..\sys\env\api;..\..\..\..\sys\mid\api;..\..\..\..\..\porting;..\..\..\..\..\any-arch\body\embenv\envcom;..\..\..\..\..\any-arch\sys\embobj\core\api;..\..\..\..\..\any-arch\sys\embobj\core\src;..\..\..\..\..\any-arch\sys\embobj\core-mee\api;..\..\..\..\..\any-arch\sys\embobj\core-mee\src;..\..\..\..\..\any-arch\sys\embobj\env\api;..\..\..\..\..\any-arch\sys\embobj\env\src;..\..\..\..\..\any-arch\sys\embobj\ipnet\api;..\..\..\..\..\any-arch\sys\embobj\ipnet\src;..\..\..\..\..\any-arch\sys\embobj\ipnet-mee\api;..\..\..\..\..\any-arch\sys\embobj\ipnet-mee\src;.;..\..\..\..\..\any-arch\sys\embobj\core-vee\api;..\..\..\..\..\any-arch\sys\embobj\core-vee\src;..\..\..\..\..\any-arch\sys\embobj\prot\src;..\..\..\..\..\any-arch\sys\embobj\prot\api;..\..\..\..\..\any-arch\sys\embobj\icub\api;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\board-eps;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-management\api;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-management\src;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-motioncontrol\api;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-motioncontrol\src;..\..\..\..\..\any-arch\sys\embobj\utils\api;..\..\..\..\..\any-arch\sys\embobj\utils\src;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-analogsensors\api;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-analogsensors\src;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-skin\api;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-skin\src;..\..\..\..\..\any-arch\sys\embobj\icub-app\api;..\..\..\..\..\any-arch\sys\embobj\icub-app\cfg;..\..\..\..\..\any-arch\sys\embobj\icub-app\src
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\eApplication.sct
target emsappl-ems001brd-normoffset (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: emsappl4mcbstm32c +hex
  c flags: Optim=1
  c define: EMSAPPL_USE_CORE HAL_USE_ARCH_ARM SHALS_MODE_STATIC
  c misc: --c99
  c include: as above
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\eApplication.sct
target emsappl-ems001brd-zerooffset (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: emsappl4mcbstm32c +hex
  c flags: Optim=1
  c define: as above
  c misc: --c99
  c include: ..\app_main;..\app_cfg;..\abslayer-cfg;..\..\..\..\sys\abs\api;..\..\..\..\sys\env\api;..\..\..\..\sys\mid\api;..\..\..\..\..\porting;..\..\..\..\..\any-arch\body\embenv\envcom;..\..\..\..\..\any-arch\sys\embobj\core\api;..\..\..\..\..\any-arch\sys\embobj\core\src;..\..\..\..\..\any-arch\sys\embobj\core-mee\api;..\..\..\..\..\any-arch\sys\embobj\core-mee\src;..\..\..\..\..\any-arch\sys\embobj\env\api;..\..\..\..\..\any-arch\sys\embobj\env\src;..\..\..\..\..\any-arch\sys\embobj\ipnet\api;..\..\..\..\..\any-arch\sys\embobj\ipnet\src;..\..\..\..\..\any-arch\sys\embobj\ipnet-mee\api;..\..\..\..\..\any-arch\sys\embobj\ipnet-mee\src;..\..\..\..\..\any-arch\sys\embobj\core-vee\api;..\..\..\..\..\any-arch\sys\embobj\core-vee\src;..\..\..\..\..\any-arch\sys\embobj\prot\src;..\..\..\..\..\any-arch\sys\embobj\prot\api;..\..\..\..\..\any-arch\sys\embobj\icub\api;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\board-eps;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-management\api;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-management\src;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-motioncontrol\api;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-motioncontrol\src;..\..\..\..\..\any-arch\sys\embobj\utils\api;..\..\..\..\..\any-arch\sys\embobj\utils\src;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-analogsensors\api;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-analogsensors\src;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-skin\api;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-skin\src;..\..\..\..\..\any-arch\sys\embobj\icub-app\api;..\..\..\..\..\any-arch\sys\embobj\icub-app\cfg;..\..\..\..\..\any-arch\sys\embobj\icub-app\src
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\eApplication-zerooffset.sct
