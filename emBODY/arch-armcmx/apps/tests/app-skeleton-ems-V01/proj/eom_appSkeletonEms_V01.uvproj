# Keil uVision project eom_appSkeletonEms_V01.uvproj, settings and files
target app-skeleton-ems-V01-zerooffset (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: udpnode +hex
  c flags: Optim=1 wLevel=2
  c define: HAL_USE_ARCH_ARM SHALS_MODE_STATIC EENV_EAPPLICATION_FORCE_CODE_OFFSET_TO_ZERO _FORCE_NETWORK_FROM_IPAL_CFG
  c misc: --c99 --forceinline
  c include: ..\app;..\app\app-eobj;..\cfg\hal-cfg;..\cfg\ipal-cfg;..\cfg\osal-cfg;..\cfg\icub-can-cfg;..\cfg\ep-nvs-cfg\com;..\cfg\ep-nvs-cfg\local;..\..\..\..\sys\abs\api;..\..\..\..\sys\env\api;..\..\..\..\sys\mid\api;..\..\..\..\..\porting;..\..\..\..\..\any-arch\body\embenv\envcom;..\..\..\..\body\embobj\embobj\embobj-api;..\..\..\..\body\embobj\embobj\embobj-src;..\..\..\..\body\embobj\embobj\embobj-icub;..\..\..\..\..\any-arch\sys\embobj\core\api;..\..\..\..\..\any-arch\sys\embobj\core\src;..\..\..\..\..\any-arch\sys\embobj\core-mee\api;..\..\..\..\..\any-arch\sys\embobj\core-mee\src;..\..\..\..\..\any-arch\sys\embobj\env\api;..\..\..\..\..\any-arch\sys\embobj\env\src;..\..\..\..\..\any-arch\sys\embobj\ipnet\api;..\..\..\..\..\any-arch\sys\embobj\ipnet\src;..\..\..\..\..\any-arch\sys\embobj\ipnet-mee\api;..\..\..\..\..\any-arch\sys\embobj\ipnet-mee\src;.;..\..\..\..\..\any-arch\sys\embobj\core-vee\api;..\..\..\..\..\any-arch\sys\embobj\core-vee\src;..\..\..\..\..\any-arch\sys\embobj\config\nvs\common;..\..\..\..\..\any-arch\sys\embobj\config\nvs\local;..\..\..\..\..\any-arch\sys\embobj\prot\src;..\..\..\..\..\any-arch\sys\embobj\prot\api
  asm misc: --cpreproc
  asm include: ..\cfg\hal-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\eApplication-zerooffset.sct
  group app
    ../app/: eom_appSkeletonEms_main.c eom_appSkeletonEms_info.c eom_appSkeletonEms_body.c
  group app-eobj
    ../app/app-eobj/: EOappCanServicesProvider.c EOappEncodersReader.c EOethBaseModule.c EOMappTheSysController.c EOMappDataCollector.c EOMappMotorController.c EOMappDataTransmitter.c
  group abslayer-lib
    ../../../../sys/abs/lib/: osal.cm3.lib hal.stm32f1.ems001.lib ipal.base.medium.lib
    ../../../../sys/abs/src/: hal_stm32f1_startup.s
  group abslayer-cfg
    ../cfg/hal-cfg/: hal_cfg.c hal_cfg.h
    ../cfg/osal-cfg/: osal_cfg.c osal_cfg.h
    ../cfg/ipal-cfg/: ipal_cfg.c ipal_cfg.h
  group eo-core
    ../../../../../any-arch/sys/embobj/core/src/: EOaction.c EOarray.c EoCommon.c EOconstarray.c EOconstvector.c EOdeque.c EOfifo.c EOfifoByte.c EOfifoWord.c EOlist.c EOtheErrorManager.c EOtheMemoryPool.c EOtimer.c EOvector.c
    ../../../../../any-arch/sys/embobj/core-vee/src/: EOVmutex.c EOVtask.c EOVtheCallbackManager.c EOVtheSystem.c EOVtheTimerManager.c
  group eo-mee
    ../../../../../any-arch/sys/embobj/core-mee/src/: EOMmutex.c EOMtask.c EOMtheCallbackManager.c EOMtheSystem.c EOMtheTimerManager.c
  group eo-ipnet
    ../../../../../any-arch/sys/embobj/ipnet-mee/src/: EOMtheIPnet.c
    ../../../../../any-arch/sys/embobj/ipnet/src/: EOpacket.c EOsocket.c EOsocketDatagram.c EOVtheIPnet.c
  group eo-arm-env
    ../../../../../any-arch/sys/embobj/env/src/: EOtheARMenvironment.c EOVtheEnvironment.c
    ../../../../../any-arch/body/embenv/envcom/: eEcommon.c
    ../../../../sys/env/src/: shalBASE.c shalINFO.c shalPART.c
  group eo-nvs-common
    ../../../../../any-arch/sys/embobj/prot/src/: EOmatrix3d.c EOnv.c EOnvsCfg.c EOreceiver.c EOrop.c EOropframe.c EOstorageEEPROM.c EOtheAgent.c EOtheFormer.c EOtheParser.c EOtransceiver.c EOtransmitter.c EOtreenode.c EOVstorage.c
  group eo-nvs-cfg-common
    ../cfg/ep-nvs-cfg/com/: eOcfg_nvsEP_base_con.c eOcfg_nvsEP_joint_con.c eOcfg_nvsEP_mngmnt_con.c
  group eo-nvs-cfg-board
    ../cfg/ep-nvs-cfg/local/: eOcfg_EPs_loc_board.c eOcfg_nvsEP_base_usr_loc_anydev.c eOcfg_nvsEP_joint_usr_loc_board.c eOcfg_nvsEP_mngmnt_usr_loc_board.c
  group eventviewer
    ../../../../sys/mid/lib/: eventviewer.cm3.lib
  group eo-develop
    ../../../../body/embobj/embobj/embobj-src/: EOconstLookupTbl.c EOemsCanNetworkTopology.c EOicubCanProto.c EOtheBOARDtransceiver.c EOVcanProto.c
  group eo-icubCan-cfg
    ../cfg/icub-can-cfg/: eOcfg_emsCanNetworkTopology.c eOcfg_icubCanProto_messagesLookupTbl.c eOcfg_icubCanProto_motorBoardMsgFunctions.c eOcfg_icubCanProto_motorBoardMsgLookupTbl.c eOcfg_icubCanProto_sensorBoardMsgFunctions.c eOcfg_icubCanProto_sensorBoardMsgLookupTbl.c
