# Keil uVision project app-skeleton-ems-V06.uvproj, settings and files
target apSkelEms-V06--ems-onRobot (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: apSkelEms-V06--ems-onRobot +hex
  c flags: Optim=4 OneElfS=1
  c define: STM32F10X_CL HAL_USE_ARCH_ARM SHALS_MODE_STATIC _USE_PROTO_TEST_ EP_EB6
  c misc: --c99 --forceinline
  c include: .;..\app_basic;..\app_extra;..\cfg\abslayer;..\cfg\icub-can-proto;..\cfg\icub-can-net;..\..\..\..\sys\abs\api;..\..\..\..\sys\env\api;..\..\..\..\sys\mid\api;..\..\..\..\sys\mid\inc;..\..\..\..\..\porting;..\..\..\..\..\any-arch\body\embenv\envcom;..\..\..\..\..\any-arch\sys\embobj\core\api;..\..\..\..\..\any-arch\sys\embobj\core\src;..\..\..\..\..\any-arch\sys\embobj\core-mee\api;..\..\..\..\..\any-arch\sys\embobj\core-mee\src;..\..\..\..\..\any-arch\sys\embobj\env\api;..\..\..\..\..\any-arch\sys\embobj\env\src;..\..\..\..\..\any-arch\sys\embobj\ipnet\api;..\..\..\..\..\any-arch\sys\embobj\ipnet\src;..\..\..\..\..\any-arch\sys\embobj\ipnet-mee\api;..\..\..\..\..\any-arch\sys\embobj\ipnet-mee\src;..\..\..\..\..\any-arch\sys\embobj\core-vee\api;..\..\..\..\..\any-arch\sys\embobj\core-vee\src;..\..\..\..\..\any-arch\sys\embobj\config\nvs\common;..\..\..\..\..\any-arch\sys\embobj\config\nvs\local;..\..\..\..\..\any-arch\sys\embobj\prot\src;..\..\..\..\..\any-arch\sys\embobj\prot\api;..\..\..\..\..\any-arch\sys\embobj\icub\api;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\board-eps;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-management\api;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-management\src;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-motioncontrol\api;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-motioncontrol\src;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-analogsensors\api;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-analogsensors\src;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-skin\api;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-skin\src;..\..\..\..\..\any-arch\sys\embobj\mc\api;..\..\..\..\..\any-arch\sys\embobj\mc\src;..\..\..\..\..\any-arch\sys\embobj\icub-ems\api;..\..\..\..\..\any-arch\sys\embobj\icub-ems\src
  asm misc: --cpreproc
  asm include: ..\cfg\abslayer
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\eApplication.sct
  group app_basic
    ../app_basic/: eom_appSkeletonEms_body.c eom_appSkeletonEms_info.c eom_appSkeletonEms_main.c
  group app-extra
    ../app_extra/: EOappCanServicesProvider.c EOappEncodersReader.c EOappTheNVmapRef.c EOethBaseModule.c EOMappDataCollector.c EOMappDataTransmitter.c EOMappMotorController.c EOMappTheSysController.c EOappTheCanBoardsManager.c proto_test.c
  group app-cfg
    ../cfg/app/: app_cfg.c app_cfg.h
  group abslayer-lib
    ../../../../sys/abs/lib/: osal.cm3.lib hal.stm32f1.mcbstm32c.lib hal.stm32f1.ems001.lib ipal.base.medium.lib osal.cm3.dbg.lib
    ../../../../sys/abs/src/: hal_stm32f1_startup.s
  group abslayer-cfg
    ../cfg/abslayer/: hal_cfg.c ipal_cfg.c osal_cfg.c hal_cfg.h ipal_cfg.h osal_cfg.h
  group eo-core
    ../../../../../any-arch/sys/embobj/core/src/: EOaction.c EOarray.c EoCommon.c EOconstarray.c EOconstvector.c EOdeque.c EOfifo.c EOfifoByte.c EOfifoWord.c EOlist.c EOtheErrorManager.c EOtheMemoryPool.c EOtimer.c EOvector.c
    ../../../../../any-arch/sys/embobj/core-vee/src/: EOVmutex.c EOVtask.c EOVtheCallbackManager.c EOVtheSystem.c EOVtheTimerManager.c
  group eo-mee
    ../../../../../any-arch/sys/embobj/core-mee/src/: EOMmutex.c EOMtask.c EOMtheCallbackManager.c EOMtheSystem.c EOMtheTimerManager.c
  group eo-ipnet
    ../../../../../any-arch/sys/embobj/ipnet-mee/src/: EOMtheIPnet.c
    ../../../../../any-arch/sys/embobj/ipnet/src/: EOpacket.c EOsocket.c EOsocketDatagram.c EOVtheIPnet.c
  group eo-arm-env
    ../../../../../any-arch/sys/embobj/env/src/: EOtheARMenvironment.c EOVtheEnvironment.c
    ../../../../../any-arch/body/embenv/envcom/: eEcommon.c
    ../../../../sys/env/src/: shalBASE.c shalINFO.c shalPART.c
  group eo-nvs-common
    ../../../../../any-arch/sys/embobj/prot/src/: EOmatrix3d.c EOnv.c EOnvsCfg.c EOreceiver.c EOrop.c EOropframe.c EOstorageEEPROM.c EOtheAgent.c EOtheFormer.c EOtheParser.c EOtransceiver.c EOtransmitter.c EOtreenode.c EOVstorage.c
  group eo-nvs-board
    ../../../../../any-arch/sys/embobj/prot/src/: EOtheBOARDtransceiver.c
  group eo-nvs-cfg-board
    ../../../../../any-arch/sys/embobj/icub-nvscfg/board-eps/: eOcfg_EPs_eb7.c eOcfg_EPs_eb4.c
    ../../../../body/embobj/embobj/embobj-icub/icub-nvscfg/cfg-eps-ebx/: eOcfg_EPs_eb6.c
  group eo-nvs-cfg-ep-mn
    ../../../../../any-arch/sys/embobj/icub-nvscfg/ep-management/src/: eOcfg_nvsEP_mn.c eOcfg_nvsEP_mn_comm_usr.c eOcfg_nvsEP_mn_appl_con.c eOcfg_nvsEP_mn_appl_usr.c eOcfg_nvsEP_mn_comm_con.c
  group eventviewer
    ../../../../sys/mid/lib/: eventviewer.cm3.lib
  group eo-nvs-cfg-mc-any
    ../../../../../any-arch/sys/embobj/icub-nvscfg/ep-motioncontrol/src/: eOcfg_nvsEP_mc.c eOcfg_nvsEP_mc_any_con_bodypart.c eOcfg_nvsEP_mc_any_con_jxx.c eOcfg_nvsEP_mc_any_con_jxxdefault.c eOcfg_nvsEP_mc_any_con_mxx.c eOcfg_nvsEP_mc_any_con_mxxdefault.c eOcfg_nvsEP_mc_any_con_cxx.c
  group eo-nvs-cfg-mc-upperleg
    ../../../../body/embobj/embobj/embobj-icub/icub-nvscfg/ep-motioncontrol/src/: eOcfg_nvsEP_mc_upperleg_usr.c eOcfg_nvsEP_mc_upperleg_con.c
  group eo-nvs-cfg-mc-lowerleg
    ../../../../../any-arch/sys/embobj/icub-nvscfg/ep-motioncontrol/src/: eOcfg_nvsEP_mc_lowerleg_con.c eOcfg_nvsEP_mc_lowerleg_usr.c
  group eo-nvs-cfg-mc-lowerarm
    ../../../../../any-arch/sys/embobj/icub-nvscfg/ep-motioncontrol/src/: eOcfg_nvsEP_mc_lowerarm_usr.c eOcfg_nvsEP_mc_lowerarm_con.c
  group eo-nvs-cfg-sk
    ../../../../../any-arch/sys/embobj/icub-nvscfg/ep-skin/src/: eOcfg_nvsEP_sk.c eOcfg_nvsEP_sk_emsboard_con.c eOcfg_nvsEP_sk_emsboard_usr.c
  group eo-nvs-cf-usrcbk-dependOnAppl
    ../cfg/icub-nvscfg-usrcbk/: eOcfg_nvsEP_mc_usrcbk_ebx.c eOcfg_nvsEP_mn_comm_usrcbk_ebx.c eOcfg_nvsEP_sk_usrcbk_ebx.c eOcfg_nvsEP_as_usrcbk_ebx.c
  group eo-icub-can
    ../../../../../any-arch/sys/embobj/icub-ems/src/: EOicubCanProto.c EOemsCanNetworkTopology.c EOVcanProto.c
  group eo-icub-can-cfg-net
    ../cfg/icub-can-net/: eOcfg_emsCanNetworkTopology_eb7.c eOcfg_emsCanNetworkTopology_eb4.c eOcfg_emsCanNetworkTopology_eb6.c
  group eo-icub-can-cfg-proto
    ../cfg/icub-can-proto/: eOcfg_icubCanProto_messagesLookupTbl.c eOcfg_icubCanProto_motorBoardMsgFunctions.c eOcfg_icubCanProto_motorBoardMsgLookupTbl.c eOcfg_icubCanProto_sensorBoardMsgFunctions.c eOcfg_icubCanProto_sensorBoardMsgLookupTbl.c
  group eo-motioncontrol
    ../../../../../any-arch/sys/embobj/mc/src/: EOspeedmeter.c EOtrajectory.c EOaxisController.c EOdecoupler.c EOemsController.c EOpid.c EOspeedcurve.c
  group eo-nvs-cfg-as
    ../../../../../any-arch/sys/embobj/icub-nvscfg/ep-analogsensors/src/: eOcfg_nvsEP_as_onestrain_usr.c eOcfg_nvsEP_as.c eOcfg_nvsEP_as_any_con_body.c eOcfg_nvsEP_as_any_con_mxx.c eOcfg_nvsEP_as_any_con_sxx.c eOcfg_nvsEP_as_onemais_con.c eOcfg_nvsEP_as_onemais_usr.c eOcfg_nvsEP_as_onestrain_con.c eOcfg_nvsEP_as_any_con_mxxdefault.c eOcfg_nvsEP_as_any_con_sxxdefault.c
