# Keil uVision project dspal.uvproj, settings and files
target dspal.cm3.lib (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: dspal.cm3 (library)
  AfterMake: cmd.exe /C copy .\Obj\dspal.cm3.lib .\dspal-lib\dspal.cm3.lib
  c flags: Optim=4 oTime=1 OneElfS=1
  c include: ..\dspal\dspal-api;..\..\..\..\sys\mid\inc;..\..\..\..\sys\mid\api
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group dspal
    ./dspal-src/: dspal.c dspal_base.c dspal_control.c dspal_fir.c dspal_math.c dspal_matrix.c dspal_statistics.c dspal_vector.c
  group cmsisdsp
    ../../../../sys/mid/lib/: cmsisdsp.cm3.lib
