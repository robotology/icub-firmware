# Keil uVision project dspal-full.uvproj, settings and files
target Simulator (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=4
  c include: .
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group cmsis
    ../../../../../sys/mid/src/: core_cm3.c system_stm32f10x.c
  group cmsis-cfg
    ../app-test/: startup_stm32f10x_cl.s
  group application
    ../app-test/: main_STM32F107.c arm_class_marks_example_f32.c
  group dspal
    ../../dspal/dspal-src/: dspal.c dspal_base.c dspal_control.c dspal_fir.c dspal_math.c dspal_matrix.c dspal_statistics.c dspal_vector.c
  group cmsisdsp
    ../../../../../sys/mid/lib/: cmsisdsp.cm3.lib
  group dspal-cfg
    ../dspal-cfg/: dspal_cfg.h dspal_cfg.c
target mcbstm32c (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_CL
  c misc: --c99
  c include: ..\app-test;..\..\..\..\..\sys\mid\api;..\..\..\..\..\sys\mid\inc;..\..\dspal\dspal-api;..\..\dspal\dspal-src
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
