# Keil uVision project hal.stm32f1-core-plus.uvproj, settings and files
target mcbstm32c (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: blinky
  c flags: Optim=1 OneElfS=1
  c define: HAL_BOARD_MCBSTM32C
  c misc: --c99
  c include: ..\..\hal\hal-api;..\..\..\..\..\sys\mid\api;..\..\..\..\..\sys\mid\inc;..\..\hal\hal-src\core;..\..\hal\hal-src\brdcfg;..\..\hal\hal-src\extra\chips;..\..\hal\hal-src\extra\devices;..\..\hal\hal-src\extra\extbrds;..\..\hal\hal-src\extra\periphs;..\..\hal\hal-src\extra\utilities;..\..\..\..\..\..\arch-armcmx
  asm misc: --cpreproc
  asm include: ..\hal-cfg\stm32f1
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ../app-test/: core-plus-stm32fx.c
  group hal-cfg
    ../hal-cfg/stm32f1/: hal_cfg.h hal_cfg.c
  group hal-startup
    ../../hal/hal-stg/: hal_startup_cpu_nam_stm32f107.s
  group hal-middleware-library
    ../../../../../sys/mid/lib/: stm32f1.lib
  group hal-brdcfg
    ../../hal/hal-src/brdcfg/: hal_brdcfg.c
  group hal-core
    ../../hal/hal-src/core/: hal_base.c hal_core.c hal_cpu.c hal_flash.c hal_heap.c hal_middleware_interface.c hal_sys.c
  group hal-extra-chips
    ../../hal/hal-src/extra/chips/: hal_chip_generic_ethtransceiver.c hal_chip_micrel_ks8893.c hal_chip_st_l3g4200d.c hal_chip_st_lis3dh.c hal_chip_xx_eeprom.c
  group hal-extra-devices
    ../../hal/hal-src/extra/devices/: hal_device_accelerometer.c hal_device_cantransceiver.c hal_device_display.c hal_device_eeprom.c hal_device_encoder.c hal_device_ethtransceiver.c hal_device_gyroscope.c hal_device_led.c hal_device_mux.c hal_device_switch.c hal_device_termometer.c
  group hal-extra-extbrds
    ../../hal/hal-src/extra/extbrds/: hal_extbrd_keil_mcbqvga.c
  group hal-extra-periphs
    ../../hal/hal-src/extra/periphs/: hal_periph_can.c hal_periph_crc.c hal_periph_dma.c hal_periph_eth.c hal_periph_gpio.c hal_periph_i2c.c hal_periph_spi.c hal_periph_timer.c hal_periph_trace.c hal_periph_uniqueid.c hal_periph_watchdog.c
  group hal-extra-utilities
    ../../hal/hal-src/extra/utilities/: hal_utility_bits.c hal_utility_crc07.c hal_utility_crc16.c hal_utility_crc32.c hal_utility_fifo.c
  group ipal
    ../../../../../sys/abs/lib/: ipal.base.medium.lib
    ../app-test/: ipal_cfg.h ipal_cfg.c
  group eviewer
    ../../../../../sys/mid/lib/: eventviewer.cm3.lib
target stm3210ceval (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: blinky
  c flags: Optim=1 OneElfS=1
  c define: HAL_BOARD_STM3210CEVAL
  c misc: --c99
  c include: ..\..\hal\hal-api;..\..\..\..\..\sys\mid\api;..\..\..\..\..\sys\mid\inc;..\..\hal\hal-src\core;..\..\hal\hal-src\brdcfg;..\..\hal\hal-src\extra\chips;..\..\hal\hal-src\extra\devices;..\..\hal\hal-src\extra\extbrds;..\..\hal\hal-src\extra\mpu;..\..\hal\hal-src\extra\utilities;..\..\..\..\..\..\arch-armcmx
  asm misc: --cpreproc
  asm include: ..\hal-cfg\stm32f1
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
target ems001 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: blinky
  c flags: Optim=1 OneElfS=1
  c define: HAL_BOARD_EMS001
  c misc: --c99
  c include: as above
  asm misc: --cpreproc
  asm include: ..\hal-cfg\stm32f1
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
