# Keil uVision project hal.stm32f1.lib-core-plus.uvproj, settings and files
target mcbstm32c (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: blinky
  c flags: Optim=4 oTime=1 OneElfS=1
  c define: HAL_BOARD_MCBSTM32C
  c misc: --c99
  c include: ..\..\hal\hal-api;..\..\..\..\..\..\arch-armcmx;..\..\hal\hal-src\brdcfg;..\..\hal\hal-src\core;..\..\..\..\..\sys\mid\api
  asm misc: --cpreproc
  asm include: ..\hal-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ../app-test/: core-plus-stm32fx.c
  group hal-cfg
    ../hal-cfg/: hal_core_cfg.h hal_core_cfg.c
  group hal-startup
    ../../hal/hal-stg/: hal_startup_cpu_nam_stm32f107.s
  group hal-lib
    ../../hal/hal-lib/: hal2.mcbstm32c.lib hal2.ems001.lib
  group ipal
    ../../../../../sys/abs/lib/: ipal.base.medium.lib
    ../app-test/: ipal_cfg.h ipal_cfg.c
  group eviewer
    ../../../../../sys/mid/lib/: eventviewer.cm3.lib
target stm3210ceval (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: blinky
  c flags: Optim=1 OneElfS=1
  c define: HAL_BOARD_STM3210CEVAL
  c misc: --c99
  c include: ..\..\hal\hal-api;..\..\..\..\..\sys\mid\api;..\..\..\..\..\sys\mid\inc;..\..\hal\hal-src\core;..\..\hal\hal-src\brdcfg;..\..\hal\hal-src\extra\chips;..\..\hal\hal-src\extra\devices;..\..\hal\hal-src\extra\extbrds;..\..\hal\hal-src\extra\periphs;..\..\hal\hal-src\extra\utilities;..\..\..\..\..\..\arch-armcmx
  asm misc: --cpreproc
  asm include: ..\hal-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
target ems001 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: blinky
  c flags: Optim=1 OneElfS=1
  c define: HAL_BOARD_EMS001
  c misc: --c99
  c include: as above
  asm misc: --cpreproc
  asm include: ..\hal-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
