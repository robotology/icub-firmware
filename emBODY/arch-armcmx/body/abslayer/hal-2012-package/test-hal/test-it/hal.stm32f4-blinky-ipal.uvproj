# Keil uVision project hal.stm32f4-blinky-ipal.uvproj, settings and files
target mcbstm32f400 (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: blinky
  c flags: Optim=1 OneElfS=1
  c define: VERY_SMALL STM32F4XX __CORTEX_M4  __FPU_PRESENT HAL_MPU_STM32F407 HAL_USE_ARCH_ARM HAL_BOARD_MCBSTM32F400
  c misc: --c99
  c include: ..\..\hal\hal-api;..\..\..\..\..\sys\mid\api;..\..\..\..\..\sys\mid\inc;..\..\hal\hal-src\base;..\..\hal\hal-src\brdcfg;..\..\hal\hal-src\chips;..\..\hal\hal-src\devices;..\..\hal\hal-src\mpu;..\..\hal\hal-src\utilities;..\..\..\..\..\..\arch-armcmx
  asm misc: --cpreproc
  asm include: ..\hal-cfg\stm32f4
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ../app-test/: blinky-ipal-hal-stm32fx.c
  group stm32fx-lib
    ../../../../../sys/mid/lib/: stm32f4.lib
  group hal-cfg
    ../hal-cfg/stm32f4/: hal_cfg.h hal_cfg.c
  group hal-startup
    ../../hal/hal-stg/: hal_stm32f4_startup.s
  group hal-cmsis
    ../../../../../sys/mid/src/: system_stm32f4xx.c
  group hal-base
    ../../hal/hal-src/base/: hal_base.c
  group hal-mpu
    ../../hal/hal-src/mpu/: hal_mpu_arch.c hal_mpu_can.c hal_mpu_crc.c hal_mpu_eth.c hal_mpu_flash.c hal_mpu_gpio.c hal_mpu_i2c.c hal_mpu_spi.c hal_mpu_sys.c hal_mpu_timer.c hal_mpu_trace.c hal_mpu_watchdog.c
  group hal-devices
    ../../hal/hal-src/devices/: hal_actuator_led.c hal_device_cantransceiver.c hal_device_display.c hal_device_eeprom.c hal_device_ethtransceiver.c hal_device_switch.c hal_sensor_accel.c hal_sensor_gyro.c hal_sensor_temp.c
  group hal-chips
    ../../hal/hal-src/chips/: hal_chip_generic_ethtransceiver.c hal_chip_micrel_ks8893.c hal_chip_st_l3g4200d.c hal_chip_st_lis3dh.c hal_chip_xx_eeprom.c
  group hal-board
    ../../hal/hal-src/brdcfg/: hal_brdcfg.c
  group hal-utilities
    ../../hal/hal-src/utilities/: hal_utility_bits.c hal_utility_crc16.c hal_utility_crc32.c hal_utility_fifo.c
  group ipal
    ../../../../../sys/abs/lib/: ipal.base.medium.lib
    ../app-test/: ipal_cfg.h ipal_cfg.c
  group eviewer
    ../../../../../sys/mid/lib/: eventviewer.cm4.lib
target ems004 (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: as above
  output: blinky
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: VERY_SMALL STM32F4XX __CORTEX_M4  __FPU_PRESENT HAL_MPU_STM32F407 HAL_USE_ARCH_ARM HAL_BOARD_EMS004
  c misc: --c99
  c include: as above
  asm misc: --cpreproc
  asm include: ..\hal-cfg\stm32f4
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
