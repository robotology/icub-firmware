# Keil uVision project hal.stm32f1.uvproj, settings and files
target hal.stm32f1.mcbstm32c.lib (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: hal.stm32f1.mcbstm32c (library)
  AfterMake: cmd.exe /C copy .\Obj\hal.stm32f1.mcbstm32c.lib .\hal-lib\hal.stm32f1.mcbstm32c.lib
  c flags: Optim=4 oTime=1 OneElfS=1
  c define: STM32F10X_CL HAL_USE_ARCH_ARM HAL_BOARD_MCBSTM32C
  c misc: --c99
  c include: ..\hal\hal-api;..\..\..\..\sys\mid\api;..\..\..\..\sys\mid\inc;.\hal-src\stm32f1
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group cmsis-from-sys
    ../../../../sys/mid/src/: system_stm32f10x.c
  group stm32f1-lib-from-sys
    ../../../../sys/mid/lib/: stm32f1.lib
  group hal-stm32
    ./hal-src/stm32f1/: hal_stm32_arch.c hal_stm32_base.c hal_stm32_crc.c hal_stm32_display.c hal_stm32_eeprom.c hal_stm32_encoder.c hal_stm32_eth.c hal_stm32_flash.c hal_stm32_gpio.c hal_stm32_led.c hal_stm32_switch.c hal_stm32_sys.c hal_stm32_timer.c hal_stm32_trace.c hal_stm32_watchdog.c hal_stm32_canfifo_hid.c hal_stm32_can.c
  group hal-stm32-extra
    ./hal-src/stm32f1/: hal_stm32_spi4encoder.c hal_stm32_i2c4hal.c
  group hal-stm32-utility
    ./hal-src/stm32f1/stm32_utility/: hal_stm32_display_GLCD_SPI_STM32.c stm32_eval_i2c_ee.c
  group hal-stm32-board
    ./hal-src/stm32f1/: hal_brdcfg.c
  group hal-utils
    ./hal-src/utils/: crc16.c crc32.c
target hal.stm32f1.mcbstm32c.slim.lib (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: hal.stm32f1.mcbstm32c.slim (library)
  AfterMake: cmd.exe /C copy .\Obj\hal.stm32f1.mcbstm32c.slim.lib .\hal-lib\hal.stm32f1.mcbstm32c.slim.lib
  c flags: Optim=4 oTime=1 OneElfS=1
  c define: STM32F10X_CL HAL_USE_ARCH_ARM HAL_BOARD_MCBSTM32C HAL_SLIM_MODE
  c misc: --c99
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
target hal.stm32f1.ems001.lib (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: hal.stm32f1.ems001 (library)
  AfterMake: cmd.exe /C copy .\Obj\hal.stm32f1.ems001.lib .\hal-lib\hal.stm32f1.ems001.lib
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_CL HAL_USE_ARCH_ARM HAL_BOARD_EMS001
  c misc: --c99
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
target hal.stm32f1.ems001.slim.lib (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: hal.stm32f1.ems001.slim (library)
  AfterMake: cmd.exe /C copy .\Obj\hal.stm32f1.ems001.slim.lib .\hal-lib\hal.stm32f1.ems001.slim.lib
  c flags: Optim=4 oTime=1 OneElfS=1
  c define: STM32F10X_CL HAL_USE_ARCH_ARM HAL_BOARD_EMS001 HAL_SLIM_MODE
  c misc: --c99
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
