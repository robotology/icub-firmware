# Keil uVision project hal-full-test-stm32lib-in-src-ems001.uvproj, settings and files
target ems001-ulinkpro (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: hal_full_test_ems001 +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_CL USE_STDPERIPH_DRIVER USE_EMS001_BOARD HAL_USE_DISPLAY HAL_USE_ETH HAL_USE_FLASH HAL_USE_GPIO HAL_USE_SYS HAL_USE_CAN HAL_USE_EEPROM HAL_USE_SPI HAL_USE_I2C
  c misc: --c99
  c include: ..\app-test;..\..\hal\hal-api;..\..\..\..\..\sys\mid\api;..\..\..\..\..\sys\mid\inc;..\..\..\..\midware\stm32-package\stm32\stm32-api;..\..\..\..\midware\stm32-package\stm32\stm32-inc;..\..\..\..\midware\stm32-package\stm32\stm32-ext;..\..\hal\hal-src\stm32
  asm misc: --cpreproc
  asm include: ..\hal-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source
    ../app-test/: main_ems001.c
  group docs
    ./: Abstract.txt
  group cmsis-from-sys
    ../../../../../sys/mid/src/: core_cm3.c system_stm32f10x.c
  group stm32-from-body
    ../../../../midware/stm32-package/stm32/stm32-src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group hal
    C:/SDL_REPO_SIMULATO/embedded/arm/embody/body/abslayer/hal-package/hal/hal-src/stm32f1/: hal_stm32.c hal_stm32_eth.c
    ../../hal/hal-src/stm32/: hal_stm32_display.c hal_stm32_display_GLCD_SPI_STM32.c hal_stm32_flash.c hal_stm32_gpio.c hal_stm32_sys.c hal_stm32_can.c hal_stm32_eeprom.c hal_stm32_spi.c hal_board_config.c hal_stm32_i2c.c
  group hal-cfg
    ../hal-cfg/: hal_cfg.h hal_cfg.c
  group hal-startup
    ../../hal/hal-stg/: hal_stm32_startup.s
  group stm32-utility
    ../../hal/hal-src/stm32/stm32_utility/: stm32_eval_i2c_ee.h stm32_eval_i2c_ee.c
target ems001-ulink2 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: Blinky +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_CL TEST_NO_OSIIT USE_STDPERIPH_DRIVER USE_MCBSTM32C_BOARD
  c include: as above
  asm misc: --cpreproc
  asm include: ..\hal-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
