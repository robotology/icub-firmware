# Keil uVision project hal-full-test-stm32lib-in-src.uvproj, settings and files
target mcbstm32c (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: hal_full_test_mcbstm32c +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_CL USE_STDPERIPH_DRIVER HAL_BOARD_MCBSTM32C
  c misc: --c99
  c include: ..\app-test;..\..\hal\hal-api;..\..\..\..\..\sys\mid\api;..\..\..\..\..\sys\mid\inc;..\..\..\..\midware\stm32f1-package\stm32f1\stm32f1-api;..\..\..\..\midware\stm32f1-package\stm32f1\stm32f1-inc;..\..\..\..\midware\stm32f1-package\stm32f1\stm32f1-ext;..\..\hal\hal-src\stm32f1
  asm misc: --cpreproc
  asm include: ..\hal-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source
    ../app-test/: main_STM32F107.c main_ems001.c
  group hal-src-cmsis-from-sys
    ../../../../../sys/mid/src/: core_cm3.c system_stm32f10x.c
  group hal-src
    ../../hal/hal-src/stm32f1/: hal_stm32_arch.c hal_stm32_base.c hal_stm32_can.c hal_stm32_display.c hal_stm32_eeprom.c hal_stm32_encoder.c hal_stm32_eth.c hal_stm32_flash.c hal_stm32_gpio.c hal_stm32_led.c hal_stm32_spi4encoder.c hal_stm32_switch.c hal_stm32_sys.c hal_stm32_timer.c hal_stm32_trace.c hal_stm32_watchdog.c hal_stm32_i2c4hal.c hal_stm32_crc.c
  group hal-src-stm32-utility
    ../../hal/hal-src/stm32f1/stm32_utility/: hal_stm32_display_GLCD_SPI_STM32.c stm32_eval_i2c_ee.c
  group hal-src-stm32-full-src-from-body
    ../../../../midware/stm32f1-package/stm32f1/stm32f1-src/: stm32f10x__misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group hal-cfg
    ../hal-cfg/: hal_cfg.h hal_cfg.c
  group hal-startup
    ../../hal/hal-stg/: hal_stm32f1_startup.s
  group hal-src-stm32-board
    ../../hal/hal-src/stm32f1/: hal_brdcfg.c
  group hal-src-utils
    ../../hal/hal-src/utils/: crc16.c crc32.c
target ems001 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: hal_full_test_mcbstm32c +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_CL USE_STDPERIPH_DRIVER HAL_BOARD_EMS001
  c misc: --c99
  c include: as above
  asm misc: --cpreproc
  asm include: ..\hal-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
