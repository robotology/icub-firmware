# Keil uVision project hal.stm32f1-full-eth.uvproj, settings and files
target mcbstm32c (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: blinky
  c flags: Optim=4 oTime=1 OneElfS=1
  c define: VERY_SMALL STM32F10X_CL HAL_MPU_STM32F107 HAL_USE_ARCH_ARM HAL_BOARD_MCBSTM32C
  c misc: --c99
  c include: ..\..\hal\hal-api;..\..\..\..\..\sys\mid\api;..\..\..\..\..\sys\mid\inc;..\..\hal\hal-src\stm32fx;..\..\..\ipal-package\ipal\ipal-api
  asm misc: --cpreproc
  asm include: ..\hal-cfg\stm32f1
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ../app-test/: blinky-hal-stm32f4-ipal.c blinky-hal-stm32f4.c
  group stm32-lib-from-sys
    ../../../../../sys/mid/lib/: stm32f1.lib
  group hal-cfg
    ../hal-cfg/stm32f1/: hal_cfg.h hal_cfg.c
  group hal-startup
    ../../hal/hal-stg/: hal_stm32f1_startup.s
  group hal-src-cmsis
    ../../../../../sys/mid/src/: system_stm32f10x.c
  group hal-src-stm32
    ../../hal/hal-src/stm32fx/: hal_stm32_arch.c hal_stm32_base.c hal_stm32_can.c hal_stm32_canfifo_hid.c hal_stm32_can-with-isr.c hal_stm32_crc.c hal_stm32_display.c hal_stm32_eeprom.c hal_stm32_encoder.c hal_stm32_eth.c hal_stm32_flash.c hal_stm32_gpio.c hal_stm32_led.c hal_stm32_switch.c hal_stm32_sys.c hal_stm32_timer.c hal_stm32_trace.c hal_stm32_watchdog.c
  group hal-src-stm32-extra
    ../../hal/hal-src/stm32fx/: hal_stm32_i2c4hal.c hal_stm32_spi4encoder.c
  group hal-stm32-utils
    ../../hal/hal-src/stm32fx/utils/: stm32ee.c stm32i2c.c stm32gpio.c
  group hal-stm32-board
    ../../hal/hal-src/stm32fx/: hal_brdcfg.c
  group hal-utils
    ../../hal/hal-src/utils/: crc32.c crc16.c
  group ipal
    ../../../../../sys/abs/lib/: ipal.base.medium.lib
    ../app-test/: ipal_cfg.h ipal_cfg.c
target ems001 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: blinky
  c flags: Optim=1 OneElfS=1
  c define: VERY_SMALL STM32F10X_CL HAL_MPU_STM32F107 HAL_USE_ARCH_ARM HAL_BOARD_EMS001
  c misc: --c99
  c include: as above
  asm misc: --cpreproc
  asm include: ..\hal-cfg\stm32f1
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
