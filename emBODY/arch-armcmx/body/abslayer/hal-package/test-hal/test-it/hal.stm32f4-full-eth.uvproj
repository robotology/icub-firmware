# Keil uVision project hal.stm32f4-full-eth.uvproj, settings and files
target mcbstm32f400 (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: blinky
  c flags: Optim=1 OneElfS=1
  c define: VERY_SMALL STM32F4XX __CORTEX_M4  __FPU_PRESENT HAL_MPU_STM32F407 HAL_USE_ARCH_ARM HAL_BOARD_MCBSTM32F400
  c misc: --c99
  c include: ..\..\hal\hal-api;..\..\..\..\..\sys\mid\api;..\..\..\..\..\sys\mid\inc;..\..\hal\hal-src\stm32fx;..\..\..\ipal-package\ipal\ipal-api
  asm misc: --cpreproc
  asm include: ..\hal-cfg\stm32f4
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ../app-test/: blinky-hal-stm32f4-ipal.c
  group stm32-lib-from-sys
    ../../../../../sys/mid/lib/: stm32f4.lib
  group hal-cfg
    ../hal-cfg/stm32f4/: hal_cfg.h hal_cfg.c
  group hal-startup
    ../../hal/hal-stg/: hal_stm32f4_startup.s
  group hal-src-cmsis
    ../../../../../sys/mid/src/: system_stm32f4xx.c
  group hal-src-stm32
    ../../hal/hal-src/stm32fx/: hal_stm32_arch.c hal_stm32_base.c hal_stm32_can.c hal_stm32_canfifo_hid.c hal_stm32_can-with-isr.c hal_stm32_crc.c hal_stm32_display.c hal_stm32_eeprom.c hal_stm32_encoder.c hal_stm32_eth.c hal_stm32_flash.c hal_stm32_gpio.c hal_stm32_led.c hal_stm32_switch.c hal_stm32_sys.c hal_stm32_timer.c hal_stm32_trace.c hal_stm32_watchdog.c
  group hal-src-stm32-extra
    ../../hal/hal-src/stm32fx/: hal_stm32_i2c4hal.c hal_stm32_spi4encoder.c
  group hal-stm32-utils
    ../../hal/hal-src/stm32fx/utils/: stm32ee.c stm32ee_cfg.c stm32i2c.c
  group hal-stm32-board
    ../../hal/hal-src/stm32fx/: hal_brdcfg.c
  group hal-utils
    ../../hal/hal-src/utils/: crc32.c crc16.c
  group ipal
    ../../../../../sys/abs/lib/: ipal.base.medium.lib
    ../app-test/: ipal_cfg.h ipal_cfg.c
target hal.stm32f2.mcbstm32f200.slim.lib (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: hal.stm32.mcbstm32c.slim (library)
  AfterMake: cmd.exe /C copy .\Obj\hal.stm32.mcbstm32c.slim.lib .\hal-lib\hal.stm32.mcbstm32c.slim.lib
  c flags: Optim=4 oTime=1 OneElfS=1
  c define: STM32F10X_CL USE_MCBSTM32C_BOARD HAL_USE_ARCH HAL_USE_FLASH HAL_USE_GPIO HAL_USE_SYS HAL_USE_EEPROM HAL_USE_I2C HAL_USE_TRACE
  c misc: --c99
  c include: ..\hal\hal-api;..\..\..\..\sys\mid\api;..\..\..\..\sys\mid\inc;.\hal-src\stm32
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
target hal.stm32f2.ems002.lib (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: hal.stm32.ems001 (library)
  AfterMake: cmd.exe /C copy .\Obj\hal.stm32.ems001.lib .\hal-lib\hal.stm32.ems001.lib
  c flags: Optim=4 oTime=1 OneElfS=1
  c define: STM32F10X_CL USE_EMS001_BOARD HAL_USE_ARCH HAL_USE_ETH HAL_USE_FLASH HAL_USE_GPIO HAL_USE_SYS HAL_USE_CAN HAL_USE_EEPROM HAL_USE_SPI HAL_USE_I2C HAL_USE_ENCODER HAL_USE_TRACE  HAL_USE_TIMER HAL_USE_LED HAL_USE_SWITCH HAL_USE_WATCHDOG
  c misc: --c99
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
target hal.stm32f2.ems002.slim.lib (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: hal.stm32.ems001.slim (library)
  AfterMake: cmd.exe /C copy .\Obj\hal.stm32.ems001.slim.lib .\hal-lib\hal.stm32.ems001.slim.lib
  c flags: Optim=4 oTime=1 OneElfS=1
  c define: STM32F10X_CL USE_EMS001_BOARD HAL_USE_ARCH HAL_USE_FLASH HAL_USE_GPIO HAL_USE_SYS HAL_USE_EEPROM HAL_USE_I2C HAL_USE_TRACE HAL_USE_SWITCH
  c misc: --c99
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
