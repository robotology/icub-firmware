# Keil uVision project hal-test-erase-eeprom.uvproj, settings and files
target mcbstm32c (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: eraseeeprom_mcbstm32c +hex
  c flags: Optim=1
  c define: STM32F10X_CL MCBSTM32C
  c misc: --c99
  c include: ..\app-test;..\..\..\..\..\sys\abs\api
  asm misc: --cpreproc
  asm include: ..\hal-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source
    ../app-test/: eraseeeprom_STM32F107.c
  group hal
    ../../../../../sys/abs/src/: hal_stm32f1_startup.s
    ../../../../../sys/abs/lib/: hal.stm32f1.mcbstm32c.lib hal.stm32f1.ems001.lib
  group hal-cfg
    ../hal-cfg/: hal_cfg.h hal_cfg.c
target ems001 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: eraseeeprom.ems001 +hex
  c flags: Optim=1
  c define: STM32F10X_CL EMS001
  c misc: --c99
  c include: ..\app-test;..\..\..\..\..\sys\abs\api
  asm misc: --cpreproc
  asm include: ..\hal-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
