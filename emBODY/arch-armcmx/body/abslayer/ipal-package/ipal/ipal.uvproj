# Keil uVision project ipal.uvproj, settings and files
target ipal.full.small (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: ipal.full.small (library)
  AfterMake: cmd.exe /C copy .\Obj\ipal.full.small.lib .\ipal-lib\ipal.full.small.lib
  c flags: Optim=4 oTime=1
  c define: IPAL_MODE_FULL IPAL_MEMORY_SMALL
  c misc: --c99
  c include: ..\ipal\ipal-api;.\ipal-src;.\ipal-extra
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group ipal
    ./ipal-src/: ipal_arp.c ipal_base.c ipal_dhcp.c ipal_eth.c ipal_ftp.c ipal_igmp.c ipal_sys.c ipal_tcp.c ipal_telnet.c ipal_tftp.c ipal_udp.c
  group tcpnet-v4.13
    ./ipal-extra/: TCP_CM3-v413.lib
  group ipal_ipiit_storage
    ./ipal-extra/: ipal_ipiit_storage.c
target ipal.full.medium (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: ipal.full.medium (library)
  AfterMake: cmd.exe /C copy .\Obj\ipal.full.medium.lib .\ipal-lib\ipal.full.medium.lib
  c flags: Optim=4 oTime=1
  c define: IPAL_MODE_FULL IPAL_MEMORY_MEDIUM
  c misc: --c99
  c include: ..\ipal\ipal-api;..\..\..\..\sys\mid\inc;..\..\..\..\sys\mid\api
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
target ipal.base.small (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: ipal.base.small (library)
  AfterMake: cmd.exe /C copy .\Obj\ipal.base.small.lib .\ipal-lib\ipal.base.small.lib
  c flags: Optim=4 oTime=1
  c define: IPAL_MODE_BASE IPAL_MEMORY_SMALL
  c misc: --c99
  c include: ..\ipal\ipal-api;.\ipal-src;.\ipal-extra
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
target ipal.base.medium (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: ipal.base.medium (library)
  AfterMake: cmd.exe /C copy .\Obj\ipal.base.medium.lib .\ipal-lib\ipal.base.medium.lib
  c flags: Optim=4 oTime=1
  c define: IPAL_MODE_BASE IPAL_MEMORY_MEDIUM
  c misc: --c99
  c include: ..\ipal\ipal-api;.\ipal-src;.\ipal-extra
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
target ipal.base.large (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: ipal.base.large (library)
  AfterMake: cmd.exe /C copy .\Obj\ipal.base.large.lib .\ipal-lib\ipal.base.large.lib
  c flags: Optim=4 oTime=1
  c define: IPAL_MODE_BASE IPAL_MEMORY_LARGE
  c misc: --c99
  c include: ..\ipal\ipal-api;.\ipal-src;.\ipal-extra
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
