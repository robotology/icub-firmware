# Keil uVision project ipal-full.uvproj, settings and files
target mcbstm32c-telnet (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: ipal_full_mcbstm32c
  c flags: Optim=1
  c define: HAL_USE_ARCH_ARM IPAL_MODE_FULL IPAL_MEMORY_MEDIUM
  c misc: --c99
  c include: ..\app-test;..\..\ipal\ipal-api;..\..\ipal\ipal-cfg;..\..\..\..\..\sys\abs\api;..\fsal-cfg;..\..\ipal\ipal-extra;..\..\ipal\ipal-src
  asm misc: --cpreproc
  asm include: ..\hal-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ../app-test/: udp_demo.c telnet_demo.c
  group ipal-cfg
    ../ipal-cfg/: ipal_cfg.h ipal_cfg.c
  group ipal
    ../../ipal/ipal-src/: ipal_arp.c ipal_base.c ipal_dhcp.c ipal_eth.c ipal_ftp.c ipal_igmp.c ipal_sys.c ipal_tcp.c ipal_telnet.c ipal_tftp.c ipal_udp.c
  group ipal-ipiit-storage
    ../../ipal/ipal-extra/: ipal_ipiit_storage.c
  group tcpnet-v4.13
    ../../ipal/ipal-extra/: TCP_CM3-v413.lib
  group hal
    ../hal-cfg/: hal_cfg.h hal_cfg.c
    ../../../../../sys/abs/lib/: hal.stm32f1.mcbstm32c.lib
    ../../../../../sys/abs/src/: hal_stm32f1_startup.s
  group fsal
    ../fsal-cfg/: fsal_cfg.h fsal_cfg.c
    ../../../../../sys/abs/lib/: fsal.cm3.lib
    ../../../../../sys/abs/src/: fsal_retarget.c
target mcbstm32c-base (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: ipal_base_mcbstm32c
  c flags: Optim=1
  c define: HAL_USE_ARCH_ARM IPAL_MODE_BASE IPAL_MEMORY_MEDIUM
  c misc: --c99
  c include: as above
  asm misc: --cpreproc
  asm include: ..\hal-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
