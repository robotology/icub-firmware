# Keil uVision project ipal-quick.uvproj, settings and files
target mcbstm32c-full (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: ipal_quick_mcbstm32c
  c flags: Optim=4 oTime=1
  c define: HAL_USE_ARCH_ARM IPAL_MODE_FULL
  c misc: --c99
  c include: ..\app-test;..\ipal-cfg;..\hal-cfg;..\..\..\..\..\sys\abs\api;..\fsal-cfg
  asm misc: --cpreproc
  asm include: ..\hal-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ../app-test/: telnet_demo.c udp_demo.c
  group ipal-cfg
    ../ipal-cfg/: ipal_cfg.h ipal_cfg.c
  group ipal
    ../../../../../sys/abs/lib/: ipal.base.medium.lib ipal.full.medium.lib
  group hal
    ../../../../../sys/abs/lib/: hal.stm32f1.mcbstm32c.lib
    ../../../../../sys/abs/src/: hal_stm32f1_startup.s
  group hal-cfg
    ../hal-cfg/: hal_cfg.c hal_cfg.h
  group fsal
    ../fsal-cfg/: fsal_cfg.h fsal_cfg.c
    ../../../../../sys/abs/lib/: fsal.cm3.lib
    ../../../../../sys/abs/src/: fsal_retarget.c
target mcbstm32c-base (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: ipal_quick_mcbstm32c
  c flags: Optim=1
  c define: HAL_USE_ARCH_ARM IPAL_MODE_BASE
  c misc: --c99
  c include: as above
  asm misc: --cpreproc
  asm include: ..\hal-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
