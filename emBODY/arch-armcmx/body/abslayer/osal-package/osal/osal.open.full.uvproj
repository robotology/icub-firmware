# Keil uVision project osal.open.full.uvproj, settings and files
target osal.open.full.cm3 (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: osal.open.cm3 (library)
  AfterMake: cmd.exe /C copy .\Obj\osal.open.cm3.lib .\osal-lib\osal.open.cm3.lib
  c flags: Optim=4 oTime=1 OneElfS=1
  c define: OOSIIT_USE_EXTERNAL_TREADSAFETY OSAL_CPUFAM_CM3 __CORTEX_M3 NDBG_MSG
  c misc: --c99
  c include: ..\osal\osal-api;..\..\..\midware\oosiit-package\oosiit\oosiit-api;..\..\..\midware\oosiit-package\oosiit\oosiit-src\cmsis-rtx-modified\cm;..\..\..\midware\oosiit-package\oosiit\oosiit-src\others;..\..\..\midware\oosiit-package\oosiit\oosiit-stg
  group oosiit
    ../../../midware/oosiit-package/oosiit/oosiit-src/cmsis-rtx-modified/cm/: HAL_CM.c HAL_CM3.c HAL_CM4.c rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Memory.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c SVC_Table.s
    ../../../midware/oosiit-package/oosiit/oosiit-src/others/: oosiit.c rt_iit_AdvTimer.c rt_iit_changes.c rt_iit_memory.c
    ../../../midware/oosiit-package/oosiit/oosiit-stg/: oosiit_storage.c
  group osal
    ./osal-src/: osal-oosiit.c
target osal.open.full.cm3.dbg (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: osal.open.cm3.dbg (library)
  AfterMake: cmd.exe /C copy .\Obj\osal.open.cm3.dbg.lib .\osal-lib\osal.open.cm3.dbg.lib
  c flags: Optim=4 oTime=1 OneElfS=1
  c define: OOSIIT_USE_EXTERNAL_TREADSAFETY OSAL_CPUFAM_CM3 __CORTEX_M3 OOSIIT_DBG_ENABLE
  c misc: --c99
  c include: ..\osal\osal-api;..\..\..\midware\oosiit-package\oosiit\oosiit-api;..\..\..\midware\oosiit-package\oosiit\oosiit-src\cmsis-rtx-modified\cm;..\..\..\midware\oosiit-package\oosiit\oosiit-src\others;..\..\..\midware\oosiit-package\oosiit\oosiit-stg;..\..\..\..\sys\mid
target osal.open.full.cm4 (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: osal.open.cm4 (library)
  AfterMake: cmd.exe /C copy .\Obj\osal.open.cm4.lib .\osal-lib\osal.open.cm4.lib
  c flags: Optim=4 oTime=1 OneElfS=1
  c define: OOSIIT_USE_EXTERNAL_TREADSAFETY OSAL_CPUFAM_CM4 __CORTEX_M4 __FPU_PRESENT
  c misc: --c99
  c include: as above
target osal.open.cm4.dbg (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: osal.open.cm4.dbg (library)
  AfterMake: cmd.exe /C copy .\Obj\osal.open.cm4.dbg.lib .\osal-lib\osal.open.cm4.dbg.lib
  c flags: Optim=4 oTime=1 OneElfS=1
  c define: OOSIIT_USE_EXTERNAL_TREADSAFETY OSAL_CPUFAM_CM4 __CORTEX_M4 __FPU_PRESENT OOSIIT_DBG_ENABLE
  c misc: --c99
  c include: as above
