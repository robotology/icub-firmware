# Keil uVision project osal.open.uvproj, settings and files
target osal.open.cm3 (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: osal.open.cm3 (library)
  AfterMake: cmd.exe /C copy .\Obj\osal.open.cm3.lib .\osal-lib\osal.open.cm3.lib
  c flags: Optim=4 oTime=1 OneElfS=1
  c define: OOSIIT_USE_EXTERNAL_TREADSAFETY OSAL_CPUFAM_CM3
  c include: ..\osal\osal-api;..\..\..\..\sys\mid\api;..\..\..\..\sys\mid\inc
  group oosiit-from-sys
    ../../../../sys/mid/lib/: oosiit.cm3.lib oosiit.cm3.dbg.lib oosiit.cm4.lib oosiit.cm4.dbg.lib
    ../../../../sys/mid/inc/: oosiit_storage.c
  group osal
    ./osal-src/: osal-oosiit.c
target osal.open.cm3.dbg (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: osal.open.cm3.dbg (library)
  AfterMake: cmd.exe /C copy .\Obj\osal.open.cm3.dbg.lib .\osal-lib\osal.open.cm3.dbg.lib
  c flags: Optim=4 oTime=1 OneElfS=1
  c define: OOSIIT_USE_EXTERNAL_TREADSAFETY OSAL_CPUFAM_CM3
  c include: as above
target osal.open.cm4 (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: osal.open.cm4 (library)
  AfterMake: cmd.exe /C copy .\Obj\osal.open.cm4.lib .\osal-lib\osal.open.cm4.lib
  c flags: Optim=4 oTime=1 OneElfS=1
  c define: OOSIIT_USE_EXTERNAL_TREADSAFETY OSAL_CPUFAM_CM4
  c include: as above
target osal.open.cm4.dbg (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: osal.open.cm4.dbg (library)
  AfterMake: cmd.exe /C copy .\Obj\osal.open.cm4.dbg.lib .\osal-lib\osal.open.cm4.dbg.lib
  c flags: Optim=4 oTime=1 OneElfS=1
  c define: OOSIIT_USE_EXTERNAL_TREADSAFETY OSAL_CPUFAM_CM4
  c include: as above
