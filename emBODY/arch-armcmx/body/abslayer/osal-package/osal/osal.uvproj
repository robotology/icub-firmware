# Keil uVision project osal.uvproj, settings and files
target osal.cm3.lib (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: osal.cm3 (library)
  AfterMake: cmd.exe /C copy .\Obj\osal.cm3.lib .\osal-lib\osal.cm3.lib
  c flags: Optim=4 oTime=1 OneElfS=1
  c define: OSIIT_USE_EXTERNAL_TREADSAFETY
  c include: ..\osal\osal-api;..\..\..\..\sys\mid\api;..\..\..\..\sys\mid\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group osiit-from-sys
    ../../../../sys/mid/lib/: osiit.cm3.lib osiit.cm3.dbg.lib osiit.cm4.lib osiit.cm4.dbg.lib
    ../../../../sys/mid/inc/: osiit_storage.c
  group osal
    ./osal-src/: osal-osiit.c
target osal.cm3.dbg.lib (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: osal.cm3.dbg (library)
  AfterMake: cmd.exe /C copy .\Obj\osal.cm3.dbg.lib .\osal-lib\osal.cm3.dbg.lib
  c flags: Optim=4 oTime=1 OneElfS=1
  c define: OSIIT_USE_EXTERNAL_TREADSAFETY
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
target osal.cm4.lib (ARM-ADS)
  device: STM32F407IE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: osal.cm4 (library)
  AfterMake: cmd.exe /C copy .\Obj\osal.cm4.lib .\osal-lib\osal.cm4.lib
  c flags: Optim=4 oTime=1 OneElfS=1
  c define: OSIIT_USE_EXTERNAL_TREADSAFETY
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target osal.cm4.dbg.lib (ARM-ADS)
  device: STM32F407IE STMicroelectronics
  cpu: as above
  output: osal.cm4.dbg (library)
  AfterMake: cmd.exe /C copy .\Obj\osal.cm4.dbg.lib .\osal-lib\osal.cm4.dbg.lib
  c flags: Optim=4 oTime=1 OneElfS=1
  c define: OSIIT_USE_EXTERNAL_TREADSAFETY
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
