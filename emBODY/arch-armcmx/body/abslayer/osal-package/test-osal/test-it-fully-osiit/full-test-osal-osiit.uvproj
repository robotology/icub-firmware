# Keil uVision project full-test-osal-osiit.uvproj, settings and files
target Simulator (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=4
  c include: .
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ../app-test/: blinky.c hwservices.c
  group cmsis-from-sys
    ../../../../../sys/mid/src/: core_cm3.c system_stm32f10x.c
  group cmsis-cfg
    ../app-test/: startup_stm32f10x_cl.s
  group stm32f1-from-sys
    ../../../../../sys/mid/lib/: stm32f1.lib
  group osal-cfg
    ../osal-cfg/: osal_cfg.h osal_cfg.c
  group osal
    ../../osal/osal-src/: osal-osiit.c
  group osiit-from-body
    ../../../../midware/osiit-package/osiit/osiit-stg/: osiit_storage.c
  group osiit-rtx-mod
    ../../../../midware/osiit-package/osiit/rl-rtx-modified/CM/: rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c HAL_CM3.c SVC_Table.s
  group osiit-ext
    ../../../../midware/osiit-package/osiit/osiit-ext/CM/: osiit.c rt_iit_AddOns.c rt_iit_AdvTimer.c rt_iit_memory.c
  group eventviewer
    ../../../../../sys/mid/lib/: eventviewer.cm3.lib
target mcbstm32c (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: Blinky +hex
  c flags: Optim=1
  c define: DBG_MSG STM32F10X_CL OSIIT_USE_EXTERNAL_TREADSAFETY DBG_MSG_SVC DBG_MSG_PENDSV DBG_MSG_SYSTICK
  c misc: --c99
  c include: ..\app-test;..\..\osal\osal-api;..\..\osal\osal-cfg;..\..\..\..\midware\osiit-package\osiit\osiit-ext\CM;..\..\..\..\midware\osiit-package\osiit\rl-rtx-modified\CM;..\..\..\..\midware\osiit-package\osiit\osiit-api;..\..\..\..\..\sys\mid\api;..\..\..\..\..\sys\mid\inc;..\..\..\..\..\sys\mid
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
