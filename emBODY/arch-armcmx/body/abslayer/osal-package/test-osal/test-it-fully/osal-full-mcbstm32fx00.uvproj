# Keil uVision project osal-full-mcbstm32fx00.uvproj, settings and files
target mcbstm32f400 (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Blinky
  c flags: Optim=1
  c define: OSIIT_USE_EXTERNAL_TREADSAFETY STM32F4XX
  c misc: --c99
  c include: ..\app-test;..\..\osal\osal-api;..\..\osal\osal-cfg;..\..\..\..\..\sys\mid\api;..\..\..\..\..\sys\mid\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ../app-test/: blinky_mcbstm32f400.c led_mcbstm32f400.c
  group cmsis
    ../../../../../sys/mid/src/: system_stm32f4xx.c
  group cmsis-cfg
    ../app-test/: startup_stm32f4xx.s
  group osal-cfg
    ../osal-cfg/: osal_cfg-stm32f4.h osal_cfg-stm32f4.c
  group osal
    ../../osal/osal-src/: osal-osiit.c
  group osiit
    ../../../../../sys/mid/inc/: osiit_storage.c
    ../../../../../sys/mid/lib/: osiit.cm4.lib
  group stm32fx
    ../../../../../sys/mid/lib/: stm32f4.lib
