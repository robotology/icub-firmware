# Keil uVision project osal-full.uvproj, settings and files
target mcbstm32c (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1
  c define: DBG_MSG OSIIT_USE_EXTERNAL_TREADSAFETY STM32F10X_CL
  c misc: --c99
  c include: ..\app-test;..\..\osal\osal-api;..\..\osal\osal-cfg;..\..\..\..\..\sys\mid\api;..\..\..\..\..\sys\mid\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ../app-test/: blinky.c hwservices.c
  group cmsis
    ../../../../../sys/mid/src/: core_cm3.c system_stm32f10x.c
  group cmsis-cfg
    ../app-test/: startup_stm32f10x_cl.s
  group stm32f1
    ../../../../../sys/mid/lib/: stm32f1.lib
  group osal-cfg
    ../osal-cfg/: osal_cfg.h osal_cfg.c
  group osal
    ../../osal/osal-src/: osal-osiit.c
  group osiit
    ../../../../../sys/mid/lib/: osiit.cm3.lib
    ../../../../../sys/mid/inc/: osiit_storage.c
