# Keil uVision project osal.open-full.uvproj, settings and files
target mcbstm32c (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1
  c define: STM32F10X_CL OOSIIT_USE_EXTERNAL_TREADSAFETY OSAL_CPUFAM_CM3
  c misc: --c99
  c include: ..\app-test;..\..\osal\osal-api;..\..\osal\osal-cfg;..\..\..\..\..\sys\mid\api;..\..\..\..\..\sys\mid\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ../app-test/: blinky.c hwservices.c
  group cmsis
    ../../../../../sys/mid/src/: core_cm3.c system_stm32f10x.c
  group cmsis-cfg
    ../app-test/: startup_stm32f10x_cl.s
  group stm32f1
    ../../../../../sys/mid/lib/: stm32f1.lib
  group osal-cfg
    ../osal-cfg/: osal_cfg-open.h osal_cfg-open.c
  group osal
    ../../osal/osal-src/: osal-oosiit.c
  group osiit
    ../../../../../sys/mid/lib/: oosiit.cm3.dbg.lib oosiit.cm3.lib
    ../../../../../sys/mid/inc/: oosiit_storage.c
  group eventviewer
    ../../../../../sys/mid/lib/: eventviewer.cm3.lib
target mcbstm32c-dbg (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: STM32F10X_CL OOSIIT_USE_EXTERNAL_TREADSAFETY
  c misc: --c99
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
