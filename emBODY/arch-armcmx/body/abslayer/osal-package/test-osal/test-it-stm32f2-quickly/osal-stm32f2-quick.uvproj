# Keil uVision project osal-stm32f2-quick.uvproj, settings and files
target mcbstm32f200 (ARM-ADS)
  device: STM32F207IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1
  c define: STM32F2XX
  c misc: --c99
  c include: ..\app-test;..\..\osal\osal-cfg;..\..\..\..\..\sys\mid\api;..\..\..\..\..\sys\mid\inc;..\..\..\..\..\sys\abs\api;..\..\..\..\..\sys\abs\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group app
    ../app-test/: led_mcbstm32f200.c blinky_mcbstm32f200.c
  group cmsis
    ../../../../../sys/mid/src/: core_cm3.c system_stm32f2xx.c
  group cmsis-cfg
    ../app-test/: startup_stm32f2xx.s
  group stm32f2
    ../../../../../sys/mid/lib/: stm32f2.lib
  group osal-cfg
    ../osal-cfg/: osal_cfg-stm32f2.c osal_cfg-stm32f2.h
  group osal-from-sys
    ../../../../../sys/abs/lib/: osal.cm3.lib
