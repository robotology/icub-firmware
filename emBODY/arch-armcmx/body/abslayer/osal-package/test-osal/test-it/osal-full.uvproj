# Keil uVision project osal-full.uvproj, settings and files
target mcbstm32c (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1
  c define: STM32F10X_CL USE_BRD_MCBSTM32_C  OSIIT_USE_EXTERNAL_TREADSAFETY
  c misc: --c99
  c include: ..\app-test;..\..\osal\osal-api;..\..\osal\osal-cfg;..\..\..\..\..\sys\mid\api;..\..\..\..\..\sys\mid\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ../app-test/: blinky-osal-stm32fx.c brd_mcbstm32x.c
  group cmsis
    ../../../../../sys/mid/src/: system_stm32f10x.c
  group cmsis-cfg
    ../app-test/: startup_stm32f10x_cl.s
  group stm32f1
    ../../../../../sys/mid/lib/: stm32f1.lib
  group osal-cfg
    ../osal-cfg/: osal_cfg.h osal_cfg.c
  group osal
    ../../osal/osal-src/: osal-osiit.c
  group osiit
    ../../../../../sys/mid/lib/: osiit.cm3.dbg.lib osiit.cm3.lib
    ../../../../../sys/mid/inc/: osiit_storage.c
  group eventviewer
    ../../../../../sys/mid/lib/: eventviewer.cm3.lib
target mcbstm32c-dbg (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: as above
  c misc: --c99
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
