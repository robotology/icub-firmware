# Keil uVision project sharserv.uvproj, settings and files
target mcbstm32c (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: sharSERV_mcbstm32c +hex
  AfterMake: cmd.exe /C copy .\Obj\sharSERV_mcbstm32c.hex .\bin\sharSERV.mcbstm32c.hex
  c flags: Optim=1
  c define: STM32F10X_CL HAL_USE_ARCH_ARM SHARSERV_MODE_SHALIB
  c misc: --c99
  c include: ..\..\api;..\..\..\..\..\sys\mid\api;..\..\..\..\..\sys\mid\inc;..\..\..\..\..\..\any-arch\body\embenv\envcom;..\..\..\..\..\sys\abs\api;..\..\..\..\..\..\porting;..\..\..\..\..\..\arch-armcmx\body\embenv\envcom
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\sharSERV.sct
  link misc: --entry sharserv_entrypoint --symdefs .\lib\sharSERV.mcbstm32c.obj
  group sources
    ../../src/: eEsharedServices.c shalBASE.c shalINFO.c shalPART.c
    ../../../../../../any-arch/body/embenv/envcom/: eEcommon.c
  group hal
    ../../../../../sys/abs/lib/: hal.stm32f1.ems001.lib hal.stm32f1.mcbstm32c.lib
target ems001 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: sharSERV_ems001 +hex
  AfterMake: cmd.exe /C copy .\Obj\sharSERV_ems001.hex .\bin\sharSERV.ems001.hex
  c flags: Optim=1
  c define: STM32F10X_CL HAL_USE_ARCH_ARM SHARSERV_MODE_SHALIB
  c misc: --c99
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\sharSERV.sct
  link misc: --entry sharserv_entrypoint --symdefs .\lib\sharSERV.ems001.obj
