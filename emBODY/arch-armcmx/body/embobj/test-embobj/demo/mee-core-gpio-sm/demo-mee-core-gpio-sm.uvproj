# Keil uVision project demo-mee-core-gpio-sm.uvproj, settings and files
target mcbstm32c (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: embobj-test +hex
  c flags: Optim=1
  c define: HAL_USE_ARCH_ARM _USE_GPIO_ _USE_STATE_MACHINES_
  c misc: --c99
  c include: ..\abslayer-cfg;..\app;..\..\..\embobj\embobj-api;..\..\..\embobj\embobj-src;..\..\..\embobj\embobj-cfg;..\..\..\..\..\sys\abs\api;..\..\..\..\..\sys\mid\api;..\..\..\..\..\sys\mid\inc;..\..\..\..\..\..\porting
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ../app/: demo-mee-core-gpio-sm-main.c demo-mee-core-gpio-sm-appl.c
  group abs-lib
    ../../../../../sys/abs/lib/: osal.cm3.lib hal.stm32f1.mcbstm32c.lib
    ../../../../../sys/abs/src/: hal_stm32f1_startup.s
  group abs-cfg
    ../abslayer-cfg/: hal_cfg.h osal_cfg.h osal_cfg.c hal_cfg_mee.c
  group eo-core
    ../../../embobj/embobj-src/: EoCommon.c EOtheErrorManager.c EOtheMemoryPool.c EOVtheSystem.c EOVtheTimerManager.c EOVtheCallbackManager.c EOVtask.c EOVmutex.c EOdeque.c EOlist.c EOvector.c EOfifo.c EOfifoByte.c EOfifoWord.c EOaction.c EOtimer.c
  group eo-mee
    ../../../embobj/embobj-src/: EOMmutex.c EOMtask.c EOMtheSystem.c EOMtheTimerManager.c EOMtheCallbackManager.c
  group eo-gpio
    ../../../embobj/embobj-src/: EOioPin.c EOioPinInput.c EOioPinInputManaged.c EOioPinOutput.c EOioPinOutputManaged.c EOtheGPIO.c EOtheGPIOManager.c EOMtheGPIOManager.c
  group eo-gpio-cfg
    ../../../embobj/embobj-cfg/: eOcfg_GPIO_MCBSTM32c.c
  group eo-sm
    ../../../embobj/embobj-src/: EOsm.c EOumlsm.c
  group eo-sm-cfg
    ../../../embobj/embobj-cfg/: eOcfg_sm_Ex2.c eOcfg_umlsm_Ex1.c
  group eo-sm-cfg-emsappl
    ../../../embobj/embobj-cfg/: eOcfg_sm_EMSappl.c
target simulator (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: embobj-test +hex
  c flags: Optim=1
  c define: STM32F10X_CL _TEST_ROPS_
  c misc: --c99
  c include: ..\abslayer-cfg;..\app;..\..\..\embobj\embobj-api;..\..\..\embobj\embobj-src;..\..\..\embobj\embobj-cfg;..\..\..\..\..\sys\abs\api;..\..\..\..\..\sys\mid\api;..\..\..\..\..\sys\mid\inc
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
