# Keil uVision project demo-mee-core-nvs-ep.uvproj, settings and files
target mcbstm32c (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: embobj-test +hex
  c flags: Optim=1 wLevel=2
  c define: HAL_USE_ARCH_ARM SHALS_MODE_STATIC EENV_EAPPLICATION_FORCE_CODE_OFFSET_TO_ZERO
  c misc: --c99
  c include: ..\abslayer-cfg;..\app;..\..\..\embobj\embobj-api;..\..\..\embobj\embobj-src;..\..\..\embobj\embobj-cfg;..\..\..\..\..\sys\abs\api;..\..\..\..\..\sys\mid\api;..\..\..\..\..\sys\mid\inc;..\..\..\..\..\sys\env\api;..\..\..\..\..\..\porting;..\..\..\..\..\..\any-arch\body\embenv\envcom;..\..\..\embobj\embobj-icub;..\..\..\embobj\embobj-icub\endpoints\mc;..\..\..\embobj\embobj-icub\endpoints\sensors;..\..\..\embobj\embobj-icub\endpoints\mngmnt;..\..\..\embobj\embobj-icub\endpoints
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xf800
  scatter file: .\eapp-sample-offset-zero.sct
  group app
    ../app/: demo-mee-core-nvs-main.c demo-mee-core-nvs-appl.c demo-info.c
  group abs-lib
    ../../../../../sys/abs/lib/: hal.stm32f1.mcbstm32c.lib osal.cm3.lib osal.cm3.dbg.lib
    ../../../../../sys/abs/src/: hal_stm32f1_startup.s
  group abs-cfg
    ../abslayer-cfg/: hal_cfg.h hal_cfg_mee.c osal_cfg.h osal_cfg.c
  group eo-core
    ../../../embobj/embobj-src/: EoCommon.c EOtheErrorManager.c EOtheMemoryPool.c EOVtheSystem.c EOVtheTimerManager.c EOVtheCallbackManager.c EOVtask.c EOVmutex.c EOdeque.c EOlist.c EOvector.c EOfifo.c EOfifoByte.c EOfifoWord.c EOaction.c EOtimer.c
  group eo-mee
    ../../../embobj/embobj-src/: EOMmutex.c EOMtask.c EOMtheSystem.c EOMtheTimerManager.c EOMtheCallbackManager.c
  group eo-nvs
    ../../../embobj/embobj-src/: EOVstorage.c EOfakeStorage.c EOconstarray.c EOnv.c EOtreenode.c EOconstvector.c EOnvsCfg.c EOrop.c EOtheParser.c EOtheFormer.c EOtheAgent.c EOstorageEEPROM.c EOropframe.c EOreceiver.c EOpacket.c EOtransmitter.c EOtransceiver.c EOarray.c EOtheBOARDtransceiver.c EOhostTransceiver.c EOmatrix3d.c
  group eo-arm-env
    ../../../embobj/embobj-src/: EOVtheEnvironment.c EOtheARMenvironment.c
    ../../../../../../any-arch/body/embenv/envcom/: eEcommon.c
    ../../../../../sys/env/src/: shalBASE.c shalINFO.c shalPART.c
  group eventviewer
    ../../../../../sys/mid/lib/: eventviewer.cm3.lib
  group ep-as-any
    ../../../embobj/embobj-icub/endpoints/sensors/: eOcfg_nvsEP_as_any_con_sxx.c eOcfg_nvsEP_as_any_con_mxx.c eOcfg_nvsEP_as_any_con_mxxdefault.c eOcfg_nvsEP_as_any_con_sxxdefault.c
  group ep-as-wholebody
    ../../../embobj/embobj-icub/endpoints/sensors/: eOcfg_nvsEP_as_wholebody_con.c eOcfg_nvsEP_as_wholebody_usr.c
  group ep-mngmnt
    ../../../embobj/embobj-icub/endpoints/mngmnt/: eOcfg_nvsEP_mngmnt_usr_ebx.c eOcfg_nvsEP_mngmnt_usr.c eOcfg_nvsEP_mngmnt_con.c
  group ep-mc-any
    ../../../embobj/embobj-icub/endpoints/mc/: eOcfg_nvsEP_mc_any_con_jxx.c eOcfg_nvsEP_mc_any_con_jxxdefault.c eOcfg_nvsEP_mc_any_con_mxx.c eOcfg_nvsEP_mc_any_con_mxxdefault.c eOcfg_nvsEP_mc_any_con_bodypart.c eOcfg_nvsEP_mc.c
  group ep-mc-leg
    ../../../embobj/embobj-icub/endpoints/mc/: eOcfg_nvsEP_mc_leg_usr.c eOcfg_nvsEP_mc_leg_con.c
  group eps-for-board-ebx (loc and rem)
    ../../../embobj/embobj-icub/endpoints/: eOcfg_EPs_ebx.c
  group ep-mc-leg-userdef-functions
    ../../../embobj/embobj-icub/endpoints/mc/: eOcfg_nvsEP_mc_leg_usr_pippo.c
  group ep-mc-upperleg
    ../../../embobj/embobj-icub/endpoints/mc/: eOcfg_nvsEP_mc_upperleg_con.c eOcfg_nvsEP_mc_upperleg_usr.c eOcfg_nvsEP_mc_upperleg_usr_pippo.c
  group ep-mc-lowerleg
    ../../../embobj/embobj-icub/endpoints/mc/: eOcfg_nvsEP_mc_lowerleg_con.c eOcfg_nvsEP_mc_lowerleg_usr.c eOcfg_nvsEP_mc_lowerleg_usr_pippo.c
  group ep-mc-usr
    ../../../embobj/embobj-icub/endpoints/mc/: eOcfg_nvsEP_mc_pippo.c
  group ep-mc-upperarm
    ../../../embobj/embobj-icub/endpoints/mc/: eOcfg_nvsEP_mc_upperarm_con.c eOcfg_nvsEP_mc_upperarm_usr.c
  group ep-mc-torso
    ../../../embobj/embobj-icub/endpoints/mc/: eOcfg_nvsEP_mc_torso_con.c eOcfg_nvsEP_mc_torso_usr.c
  group ep-mc-lowerarm
    ../../../embobj/embobj-icub/endpoints/mc/: eOcfg_nvsEP_mc_lowerarm_con.c eOcfg_nvsEP_mc_lowerarm_usr.c
