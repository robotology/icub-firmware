# Keil uVision project demo-mee-core-nvs.uvproj, settings and files
target mcbstm32c (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: embobj-test +hex
  c flags: Optim=1 wLevel=2
  c define: HAL_USE_ARCH_ARM SHALS_MODE_STATIC EENV_EAPPLICATION_FORCE_CODE_OFFSET_TO_ZERO
  c misc: --c99
  c include: ..\abslayer-cfg;..\app;..\..\..\embobj\embobj-api;..\..\..\embobj\embobj-src;..\..\..\embobj\embobj-cfg;..\..\..\..\..\sys\abs\api;..\..\..\..\..\sys\mid\api;..\..\..\..\..\sys\mid\inc;..\..\..\..\..\sys\env\api;..\..\..\..\..\sys\prt
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xf800
  scatter file: .\eapp-sample-offset-zero.sct
  group app
    ../app/: demo-mee-core-nvs-main.c demo-mee-core-nvs-appl.c demo-info.c
  group abs-lib
    ../../../../../sys/abs/lib/: hal.stm32f1.mcbstm32c.lib osal.cm3.lib osal.cm3.dbg.lib
    ../../../../../sys/abs/src/: hal_stm32f1_startup.s
  group abs-cfg
    ../abslayer-cfg/: hal_cfg.h hal_cfg_mee.c osal_cfg.h osal_cfg.c
  group eo-core
    ../../../embobj/embobj-src/: EoCommon.c EOtheErrorManager.c EOtheMemoryPool.c EOVtheSystem.c EOVtheTimerManager.c EOVtheCallbackManager.c EOVtask.c EOVmutex.c EOdeque.c EOlist.c EOvector.c EOfifo.c EOfifoByte.c EOfifoWord.c EOaction.c EOtimer.c
  group eo-mee
    ../../../embobj/embobj-src/: EOMmutex.c EOMtask.c EOMtheSystem.c EOMtheTimerManager.c EOMtheCallbackManager.c
  group eo-nvs
    ../../../embobj/embobj-src/: EOVstorage.c EOfakeStorage.c EOconstarray.c EOnv.c EOtreenode.c EOconstvector.c EOnvsCfg.c EOrop.c EOtheParser.c EOtheFormer.c EOtheAgent.c EOstorageEEPROM.c EOropframe.c EOreceiver.c EOpacket.c EOtransmitter.c EOtransceiver.c EOarray.c EOtheBOARDtransceiver.c EOhostTransceiver.c EOmatrix3d.c
  group eo-nvs-cfg-common
    ../../../embobj/embobj-cfg/: eOcfg_nvsEP_base_con.c eOcfg_nvsEP_mngmnt_con.c
  group eo-nvs-cfg-local
    ../../../embobj/embobj-cfg/: eOcfg_EPs_loc_board.c eOcfg_nvsEP_base_usr_loc_anydev.c eOcfg_nvsEP_mngmnt_usr_loc_board.c
  group eo_nvs-cfg-remote
    ../../../embobj/embobj-cfg/: eOcfg_nvsEP_base_usr_rem_anydev.c eOcfg_nvsEP_mngmnt_usr_rem_board.c eOcfg_EPs_rem_board.c
  group eo-arm-env
    ../../../embobj/embobj-src/: EOVtheEnvironment.c EOtheARMenvironment.c
    ../../../../embenv/envcom/: eEcommon.c
    ../../../../embenv/envshalib/shalBASE-package/shalBASE/src/: shalBASE.c
    ../../../../embenv/envshalib/shalPART-package/shalPART/src/: shalPART.c
    ../../../../embenv/envshalib/shalINFO-package/shalINFO/src/: shalINFO.c
  group eventviewer
    ../../../../../sys/mid/lib/: eventviewer.cm3.lib
target simulator (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: embobj-test +hex
  c flags: Optim=1
  c define: STM32F10X_CL _TEST_ROPS_
  c misc: --c99
  c include: ..\abslayer-cfg;..\app;..\..\..\embobj\embobj-api;..\..\..\embobj\embobj-src;..\..\..\embobj\embobj-cfg;..\..\..\..\..\sys\abs\api;..\..\..\..\..\sys\mid\api;..\..\..\..\..\sys\mid\inc
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
