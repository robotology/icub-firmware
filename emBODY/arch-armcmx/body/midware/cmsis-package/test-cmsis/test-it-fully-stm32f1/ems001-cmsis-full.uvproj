# Keil uVision project ems001-cmsis-full.uvproj, settings and files
target ems001-ulinkpro (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: CMSIS_Example
  c flags: Optim=1
  c define: STM32F10X_CL
  c include: ..\..\cmsis\cmsis-api;..\..\cmsis\cmsis-inc\core;..\..\cmsis\cmsis-inc\dev-stm32
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group cmsis
    ../../cmsis/cmsis-src/dev-stm32/: system_stm32f10x.c
    ../../cmsis/cmsis-src/core/: core_cm3.c
  group cmsis-cfg
    ../cmsis-cfg/stm32-armcc/: startup_stm32f10x_cl.s
  group application
    ../app-test/: main_ems001.c
target ems001-ulink2 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: CMSIS_Example
  c flags: Optim=1
  c define: STM32F10X_CL
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
