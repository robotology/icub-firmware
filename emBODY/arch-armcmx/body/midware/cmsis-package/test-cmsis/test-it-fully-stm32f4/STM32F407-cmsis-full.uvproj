# Keil uVision project STM32F407-cmsis-full.uvproj, settings and files
target mcbstm32f400 (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: CMSIS_Example
  c flags: Optim=1
  c misc: --c99
  c include: ..\..\cmsis\cmsis-api;..\..\cmsis\cmsis-inc\core;..\..\cmsis\cmsis-inc\dev-stm32
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group cmsis
    ../../cmsis/cmsis-src/core/: core_cm3.c
    ../../cmsis/cmsis-src/dev-stm32/: system_stm32f4xx.c
  group cmsis-cfg
    ../cmsis-cfg/stm32-armcc/: startup_stm32f4xx.s
  group application
    ../app-test/: led_mcbstm32f400.c main_mcbstm32f400.c
