# Keil uVision project CMSIS_LM3S-quick.uvproj, settings and files
target EK-LM3S3748 (ARM-ADS)
  device: LM3S3748 Luminary Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x1FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: CMSIS_Example
  c flags: Optim=1
  c include: ..\cmsis-cfg\lm3s-armcc;..\..\..\..\..\sys\mid\api;..\..\..\..\..\sys\mid\inc
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group cmsis-from-sys
    ../../../../../sys/mid/src/: core_cm3.c system_LM3S.c
  group cmsis-cfg-local
    ../cmsis-cfg/lm3s-armcc/: startup_LM3S.s lm3s_config.h
  group application
    ../app-test/: main_LM3S6965-mod.c
