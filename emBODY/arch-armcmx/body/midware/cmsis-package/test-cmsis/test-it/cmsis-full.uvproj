# Keil uVision project cmsis-full.uvproj, settings and files
target mcbstm32 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: CMSIS_Example
  c flags: Optim=1
  c define: STM32F10X_MD USE_BRD_MCBSTM32
  c misc: --c99
  c include: ..\..\cmsis\cmsis-api;..\..\cmsis\cmsis-inc\core;..\..\cmsis\cmsis-inc\dev-stm32
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group cmsis
    ../../cmsis/cmsis-src/dev-stm32/: system_stm32f10x.c system_stm32f2xx.c system_stm32f4xx.c
  group cmsis-cfg
    ../../cmsis/cmsis-cfg/stm32-armcc/: startup_stm32f10x_md.s
    ../cmsis-cfg/stm32-armcc/: startup_stm32f10x_cl.s startup_stm32f2xx.s startup_stm32f4xx.s
  group application
    ../app-test/: blinky-stm32fx.c brd_mcbstm32x.c systickservices.c
target mcbstm32c (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: CMSIS_Example
  c flags: Optim=4 oTime=1
  c define: STM32F10X_CL USE_BRD_MCBSTM32_C
  c misc: --c99
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
target mcbstm32f200 (ARM-ADS)
  device: STM32F207IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: CMSIS_Example
  c flags: Optim=4 oTime=1
  c define: USE_BRD_MCBSTM32_F200
  c misc: --c99
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
target mcbstm32f400 (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: CMSIS_Example
  c flags: Optim=1
  c define: STM32F4XX USE_BRD_MCBSTM32_F400 __CORTEX_M4  __FPU_PRESENT
  c misc: --c99
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
