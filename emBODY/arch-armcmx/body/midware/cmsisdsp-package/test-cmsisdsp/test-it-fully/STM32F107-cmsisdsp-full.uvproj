# Keil uVision project STM32F107-cmsisdsp-full.uvproj, settings and files
target MCBSTM32C (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: CMSIS_Example
  c flags: Optim=1
  c define: STM32F10X_CL ARM_MATH_CM3
  c include: ..\..\..\..\..\sys\mid\api;..\..\cmsisdsp\cmsisdsp-api;..\..\cmsisdsp\cmsisdsp-inc;..\..\..\..\..\sys\mid\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group cmsis
    ../../../../../sys/mid/src/: system_stm32f10x.c
  group cmsis-cfg
    ../cmsis-cfg/: startup_stm32f10x_cl.s
  group application
    ../app-test/: main_STM32F107.c arm_class_marks_example_f32.c
  group cmsisdsp
    ../../cmsisdsp/cmsisdsp-lib/: cmsisdsp.cm3.lib
