# Keil uVision project cmsisdsp-quick.uvproj, settings and files
target mcbstm32c (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: CMSIS_Example
  c flags: Optim=4 oTime=1
  c define: STM32F10X_CL USE_BRD_MCBSTM32_C ARM_MATH_CM3
  c misc: --c99
  c include: ..\..\..\..\..\sys\mid\api;..\..\..\..\..\sys\mid\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group cmsis
    ../../../../../sys/mid/src/: system_stm32f10x.c system_stm32f2xx.c system_stm32f4xx.c
  group cmsis-cfg
    ../cmsis-cfg/stm32-armcc/: startup_stm32f10x_cl.s startup_stm32f2xx.s startup_stm32f4xx.s
  group application
    ../app-test/: blinky-dsp-stm32fx.c brd_mcbstm32x.c systickservices.c arm_class_marks_example_f32.c
  group cmsisdsp
    ../../../../../sys/mid/lib/: cmsisdsp.cm3.lib cmsisdsp.cm4.lib
  group eventviewer
    ../../../../../sys/mid/lib/: eventviewer.cm3.lib eventviewer.cm4.lib
target mcbstm32f200 (ARM-ADS)
  device: STM32F207IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: CMSIS_Example
  c flags: Optim=4 oTime=1
  c define: USE_BRD_MCBSTM32_F200 ARM_MATH_CM3
  c misc: --c99
  c include: ..\..\..\..\..\sys\mid\api;..\..\..\..\..\sys\mid\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
target mcbstm32f400 (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: CMSIS_Example
  c flags: Optim=4 oTime=1
  c define: STM32F4XX USE_BRD_MCBSTM32_F400 __CORTEX_M4  __FPU_PRESENT ARM_MATH_CM4
  c misc: --c99
  c include: ..\..\..\..\..\sys\mid\api;..\..\..\..\..\sys\mid\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
