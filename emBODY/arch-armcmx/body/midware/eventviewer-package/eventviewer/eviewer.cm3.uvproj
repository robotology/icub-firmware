# Keil uVision project eviewer.cm3.uvproj, settings and files
target ARM_LE (ARM-ADS)
  device: ARM7 (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: FS_ARM_L (library)
  c flags: Optim=4 OneElfS=1
  scatter file: RTLFS.sct
  group eventviewer
    ./eventviewer-src/: eventviewer.c
target eventviewer-cm3 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: eventviewer.cm3 (library)
  AfterMake: cmd.exe /C copy .\Obj\eventviewer.cm3.lib .\eventviewer-lib\eventviewer.cm3.lib
  c flags: Optim=4 oTime=1
  c include: .\eventviewer-api
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: RTLFS.sct
