# Keil uVision project STM32F107-ev-full.uvproj, settings and files
target mcbstm32c (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: CMSIS_Example
  c flags: Optim=1
  c define: STM32F10X_CL
  c misc: --c99
  c include: ..\..\eventviewer\eventviewer-api;..\..\..\..\..\sys\mid\api;..\..\..\..\..\sys\mid\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group cmsis
    ../../../../../sys/mid/src/: core_cm3.c system_stm32f10x.c
  group cmsis-cfg
    ../cmsis-cfg/stm32-armcc/: startup_stm32f10x_cl.s
  group application
    ../app-test/: main_STM32F107.c
  group eventviewer
    ../../eventviewer/eventviewer-src/: eventviewer.c
