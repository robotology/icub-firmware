# Keil uVision project eventviewer-full.uvproj, settings and files
target mcbstm32c (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: CMSIS_Example
  c flags: Optim=1
  c define: STM32F10X_CL USE_BRD_MCBSTM32_C
  c misc: --c99
  c include: ..\..\eventviewer\eventviewer-api;..\..\..\..\..\sys\mid\api;..\..\..\..\..\sys\mid\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group cmsis
    ../../../../../sys/mid/src/: system_stm32f10x.c system_stm32f4xx.c
  group cmsis-cfg
    ../cmsis-cfg/stm32-armcc/: startup_stm32f4xx.s startup_stm32f10x_cl.s
  group application
    ../app-test/: blinky-ev-stm32fx.c brd_mcbstm32x.c systickservices.c
  group eventviewer
    ../../eventviewer/eventviewer-src/: eventviewer.c
  group stm32fx
    ../../../../../sys/mid/lib/: stm32f1.lib stm32f4.lib
target mcbstm32f400 (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: CMSIS_Example
  c flags: Optim=1
  c define: STM32F4XX USE_BRD_MCBSTM32_F400 __CORTEX_M4  __FPU_PRESENT
  c misc: --c99
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
