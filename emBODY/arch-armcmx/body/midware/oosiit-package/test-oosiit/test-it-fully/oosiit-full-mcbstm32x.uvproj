# Keil uVision project oosiit-full-mcbstm32x.uvproj, settings and files
target mcbstm32c (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1
  c define: USE_BRD_MCBSTM32_C __CORTEX_M3  STM32F10X_CL NDBG_MSG NDBG_MSG_SVC NDBG_MSG_PENDSV NDBG_MSG_SYSTICK
  c misc: --c99
  c include: ..\app-test;..\oosiit-cfg;..\..\oosiit\oosiit-api;..\..\oosiit\oosiit-src\cmsis-rtx-modified\cm;..\..\oosiit\oosiit-src\others;..\..\oosiit\oosiit-stg;..\..\..\..\..\sys\mid\api;..\..\..\..\..\sys\mid\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group application
    ../app-test/: blinky-stm32fx.c brd_mcbstm32x.c
  group cmsis-from-sys
    ../../../../../sys/mid/src/: core_cm3.c system_stm32f10x.c
  group cmsis-config
    ../app-test/: startup_stm32f10x_cl.s
  group stm32f1-from-sys
    ../../../../../sys/mid/lib/: stm32f1.lib
  group oosiit-cfg
    ../oosiit-cfg/: oosiit_cfg.h oosiit_cfg.c
  group cmsis-rtx-src-modified
    ../../oosiit/oosiit-src/cmsis-rtx-modified/cm/: rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Memory.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
  group cmsis-rtx-cfg-modified
    ../../oosiit/oosiit-src/cmsis-rtx-modified/cm/: HAL_CM.c HAL_CM0.c HAL_CM3.c HAL_CM4.c SVC_Table.s
  group others
    ../../oosiit/oosiit-src/others/: oosiit.c rt_iit_AdvTimer.c rt_iit_changes.c rt_iit_memory.c
