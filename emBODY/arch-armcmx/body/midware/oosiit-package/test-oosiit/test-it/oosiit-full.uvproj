# Keil uVision project oosiit-full.uvproj, settings and files
target mcbstm32c (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=4 oTime=1
  c define: USE_BRD_MCBSTM32_C __CORTEX_M3  STM32F10X_CL
  c misc: --c99
  c include: ..\app-test;..\oosiit-cfg;..\..\oosiit\oosiit-api;..\..\oosiit\oosiit-src\cmsis-rtx-modified\cm;..\..\oosiit\oosiit-src\others;..\..\oosiit\oosiit-stg;..\..\..\..\..\sys\mid\api;..\..\..\..\..\sys\mid\inc;..\..\..\..\..\sys\mid\
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group application
    ../app-test/: blinky-stm32fx.c adv-tests-stm32fx.c brd_mcbstm32x.c
  group cmsis-from-sys
    ../../../../../sys/mid/src/: system_stm32f10x.c system_stm32f4xx.c
  group cmsis-config
    ../app-test/: startup_stm32f10x_cl.s startup_stm32f4xx.s
  group stm32fx-from-sys
    ../../../../../sys/mid/lib/: stm32f1.lib stm32f4.lib
  group oosiit-cfg
    ../oosiit-cfg/: oosiit_cfg.h oosiit_cfg.c
  group cmsis-rtx-src-modified
    ../../oosiit/oosiit-src/cmsis-rtx-modified/cm/: rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Memory.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
  group cmsis-rtx-cfg-modified
    ../../oosiit/oosiit-src/cmsis-rtx-modified/cm/: HAL_CM.c HAL_CM0.c HAL_CM3.c HAL_CM4.c SVC_Table.s
  group others
    ../../oosiit/oosiit-src/others/: oosiit.c rt_iit_AdvTimer.c rt_iit_changes.c rt_iit_memory.c
  group eventviewer
    ../../../../../sys/mid/lib/: eventviewer.cm4.lib eventviewer.cm3.lib
    ../../../eventviewer-package/eventviewer/eventviewer-src/: eventviewer.c
target mcbstm32c-dbg (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: USE_BRD_MCBSTM32_C __CORTEX_M3  STM32F10X_CL OOSIIT_DBG_ENABLE_ALL
  c misc: --c99
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
target mcbstm32f400 (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Blinky
  c flags: Optim=4 oTime=1
  c define: STM32F4XX USE_BRD_MCBSTM32_F400 __CORTEX_M4  __FPU_PRESENT
  c misc: --c99
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target mcbstm32f400-dbg (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1 wLevel=2
  c define: STM32F4XX USE_BRD_MCBSTM32_F400 __CORTEX_M4  __FPU_PRESENT OOSIIT_DBG_ENABLE
  c misc: --c99
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
