# Keil uVision project stm32f1.uvproj, settings and files
target stm32f1-iit (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32f1 (library)
  AfterMake: cmd.exe /C copy .\Obj\stm32f1.lib .\stm32f1-lib\stm32f1.lib
  c flags: Optim=4 oTime=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER STM32F10X_CL
  c include: .\stm32f1-api;.\stm32f1-inc;.\stm32f1-ext;..\..\cmsis-package\cmsis\cmsis-inc\core;..\..\cmsis-package\cmsis\cmsis-inc\dev-stm32
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group stm32f1-src-original
    ./stm32f1-src/: stm32f10x__misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
target STM32 Library - Debug (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: as above
  output: STM32F10x (library)
  AfterMake: cmd.exe /C copy .\Debug\STM32F10x.LIB ..\STM32F10xD.LIB
  c flags: Optim=1 OneElfS=1
  c define: DEBUG
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
