# Keil uVision project STM32F107-full.uvproj, settings and files
target mcbstm32c (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: CMSIS_Example
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER STM32F10X_CL
  c include: ..\..\stm32f1\stm32f1-api;..\..\stm32f1\stm32f1-inc;..\app-test;..\..\stm32f1\stm32f1-ext;..\..\..\cmsis-package\cmsis\cmsis-api\core;..\..\..\cmsis-package\cmsis\cmsis-api\dev-stm32;..\..\..\cmsis-package\cmsis\cmsis-inc\core;..\..\..\cmsis-package\cmsis\cmsis-inc\dev-stm32
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group cmsis-from-body
    ../../../cmsis-package/cmsis/cmsis-src/dev-stm32/: system_stm32f10x.c
  group cmsis-cfg-local
    ../cmsis-cfg/: startup_stm32f10x_cl.s
  group application
    ../app-test/: main_STM32F107.c flash.c
  group stm32f1
    ../../stm32f1/stm32f1-src/: stm32f10x__misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
