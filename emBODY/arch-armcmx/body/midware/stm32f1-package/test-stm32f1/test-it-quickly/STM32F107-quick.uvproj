# Keil uVision project STM32F107-quick.uvproj, settings and files
target MCBSTM32C-quick (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: CMSIS_Example
  c flags: Optim=1
  c define: STM32F10X_CL
  c include: ..\app-test;..\..\..\..\..\sys\mid\api;..\..\..\..\..\sys\mid\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group cmsis-from-sys
    ../../../../../sys/mid/src/: system_stm32f10x.c
  group cmsis-cfg-local
    ../cmsis-cfg/: startup_stm32f10x_cl.s
  group application
    ../app-test/: main_STM32F107.c flash.c
  group stm32f1-from-sys
    ../../../../../sys/mid/lib/: stm32f1.lib
