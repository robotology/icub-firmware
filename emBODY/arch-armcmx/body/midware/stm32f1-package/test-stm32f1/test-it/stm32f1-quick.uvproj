# Keil uVision project stm32f1-quick.uvproj, settings and files
target mcbstm32c (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: CMSIS_Example
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER STM32F10X_CL USE_BRD_MCBSTM32_C
  c include: ..\..\stm32f1\stm32f1-api;..\..\stm32f1\stm32f1-inc;..\app-test;..\..\stm32f1\stm32f1-ext;..\..\..\..\..\sys\mid\api;..\..\..\..\..\sys\mid\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group cmsis
    ../../../../../sys/mid/src/: system_stm32f10x.c
  group cmsis-cfg
    ../cmsis-cfg/: startup_stm32f10x_cl.s
  group application
    ../app-test/: blinky-stm32f1-stm32fx.c stm32f1_flash.c brd_mcbstm32x.c systickservices.c
  group stm32f1
    ../../../../../sys/mid/lib/: stm32f1.lib
