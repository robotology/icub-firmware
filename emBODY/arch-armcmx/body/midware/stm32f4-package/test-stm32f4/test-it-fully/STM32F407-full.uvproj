# Keil uVision project STM32F407-full.uvproj, settings and files
target mcbstm32f400 (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: stm32f4
  c flags: Optim=1 wLevel=2
  c define: STM32F4XX USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: .;..\..\stm32f4\stm32f4-api;..\..\stm32f4\stm32f4-inc;..\app-test;..\..\stm32f4\stm32f4-ext;..\..\..\cmsis-package\cmsis\cmsis-api\core;..\..\..\cmsis-package\cmsis\cmsis-api\dev-stm32;..\..\..\cmsis-package\cmsis\cmsis-inc\core;..\..\..\cmsis-package\cmsis\cmsis-inc\dev-stm32;..\..\..\cmsis-package\cmsis\cmsis-api
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group cmsis-from-body
    ../../../cmsis-package/cmsis/cmsis-src/core/: core_cm3.c
    ../../../cmsis-package/cmsis/cmsis-src/dev-stm32/: system_stm32f4xx.c
  group cmsis-cfg-local
    ../cmsis-cfg/: startup_stm32f4xx.s
  group application
    ../app-test/: led_mcbstm32f400.c main_STM32F407.c
  group stm32f4
    ../../stm32f4/stm32f4-src/: stm32f4xx__misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
