# Keil uVision project STM32F407-quick.uvproj, settings and files
target mcbstm32f400 (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: stm32f4
  c flags: Optim=1 wLevel=2
  c define: STM32F4XX
  c include: ..\app-test;..\..\..\..\..\sys\mid\api;..\..\..\..\..\sys\mid\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group cmsis-from-sys
    ../../../../../sys/mid/src/: system_stm32f4xx.c
  group cmsis-cfg-local
    ../cmsis-cfg/: startup_stm32f4xx.s
  group application
    ../app-test/: led_mcbstm32f400.c main_STM32F407.c
  group lib-to-be-added
    ../../../../../sys/mid/lib/: stm32f4.lib
