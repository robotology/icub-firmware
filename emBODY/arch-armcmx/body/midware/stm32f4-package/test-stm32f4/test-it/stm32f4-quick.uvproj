# Keil uVision project stm32f4-quick.uvproj, settings and files
target mcbstm32f400 (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: stm32f4
  c flags: Optim=1
  c define: STM32F4XX USE_BRD_MCBSTM32_F400
  c include: ..\app-test;..\..\..\..\..\sys\mid\api;..\..\..\..\..\sys\mid\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group cmsis
    ../../../../../sys/mid/src/: system_stm32f4xx.c
  group cmsis-cfg
    ../cmsis-cfg/: startup_stm32f4xx.s
  group application
    ../app-test/: blinky-stm32f4-stm32fx.c brd_mcbstm32x.c systickservices.c
  group stm32f4
    ../../../../../sys/mid/lib/: stm32f4.lib
