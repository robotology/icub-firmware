# Keil uVision project eproc02.eapplbasic.ems001.burnflash.uvproj, settings and files
target stm32.ems001 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: eproc02.eApplBasic_ems001.hex
  c flags: Optim=1
  memory RVCT4: ROM 0x8001000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x10000
