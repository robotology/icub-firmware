# Keil uVision project eraseeepromflash.mcbstm32c.burnflash.uvproj, settings and files
target stm32.mcbstm32c (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: eraseeeprom.mcbstm32c.hex
  c flags: Optim=1
  memory RVCT4: ROM 0x8001000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x10000
