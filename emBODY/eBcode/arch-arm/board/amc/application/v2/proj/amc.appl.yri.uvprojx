# Keil uVision project amc.appl.yri.uvprojx, settings and files
target amc-icc-osal-ulpro (6240000::V6.24::ARMCLANG)
  device: STM32H745IIKx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x38000000,0x00010000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) XRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: amc_appl_yri +hex
  AfterMake: cmd.exe /C copy .\obj\amc_appl_yri.hex ..\bin\amc.appl.yri.hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: USE_ICC_COMM USE_EMBOT_HW EMBOBJ_USE_EMBOT USE_STM32HAL STM32HAL_BOARD_AMC STM32HAL_DRIVER_V1A0 WRIST_MK2
  c misc: -DuseICCserviceCAN -DxdebugNOicc -DxYRI_uses_MC_foc_actuator_descriptor_generic -DxuseMCfoc_actuator_descriptor_generic -Wno-pragma-pack -Wno-deprecated-register -DEMBOT_USE_rtos_osal -DIPAL_use_cfg2 -DUSE_EMBOT_theHandler -DUSE_EMBOT_theServices -DUSE_EMBOT_theServicesMC
  c include: ..\..\..\..\..\libs\lowlevel\stm32hal\api;..\..\..\..\..\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\embot\hw;..\..\..\..\..\embot\os;..\..\..\..\..\embot\app;..\..\..\..\..\libs\midware\eventviewer\api;..\..\..\..\..\libs\highlevel\abslayer\ipal\api;--..\..\..\..\..\libs\highlevel\abslayer\hal2\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core;..\..\..\..\..\embobj\core\exec\multitask;..\..\..\..\..\embobj\plus\ipnet;..\src\emb-env;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\prot\eth;..\..\..\bsp;..\cfg;..\..\..\bsp\ethdriver;..\..\..\..\..\libs\highlevel\services\embenv\api;..\..\..\..\..\embobj\plus\embenv;..\..\..\..\..\libs\highlevel\abslayer\hal2\api;..\..\..\..\..\embobj\plus\ctrloop;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\icub;..\..\..\..\..\..\..\..\..\icub-firmware-shared\can\canProtocolLib;..\..\..\..\..\embot\app\eth;.;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\transport;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\protocol\api;..\cfg\protocol\rop;..\..\..\..\..\embobj\plus\can;..\..\..\..\ems004\appl\v2\src\eoappservices;..\..\..\..\..\embobj\plus\board;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\tools;..\..\..\..\..\mbd\kalman_filter;..\..\..\..\..\embobj\plus\mc;..\..\..\..\..\libs\midware\hl-plus\api;..\..\..\..\..\embot\prot\can;..\..\..\..\..\mbd\wrist_decoupler;..\..\..\..\..\mbd\torque_estimator
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT9: RAM 0x38000000 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: ..\cfg\amc-template-appl.sct
  link misc: --diag_suppress=L6329
  group main
    ../src/: amc-appl-02.cpp
  group embot::app::eth
    ../../../../../embot/app/eth/: embot_app_eth_theApplication.cpp embot_app_eth_theIPnet.cpp embot_app_eth_theEnvironment.cpp embot_app_eth_theErrorManager.cpp embot_app_eth_theUpdaterParser.cpp embot_app_eth_theListener.cpp embot_app_eth_theBackdoor.cpp embot_app_eth_theETHmonitor.cpp
    ../../../../../embot/app/: embot_app_theLEDmanager.cpp
  group embot::app::eth::config
    ../cfg/: theApplication_config.h theApplication_config.cpp
  group stm32hal
    ../../../../../libs/lowlevel/stm32hal/lib/: stm32hal.h7.amc.v1A0.lib
    ../cfg/: startup_stm32h745xx_CM7.s
  group rtos
    ../../../../../libs/highlevel/abslayer/osal/lib/: osal.cm4.dbg.lib osal.cm4.lib
    ../../../../../libs/midware/eventviewer/src/: eventviewer.c
  group ipal
    ../../../../../libs/highlevel/abslayer/ipal/lib/: ipal.lwip.h7.lib
    ../cfg/: ipal_cfg2.cpp
  group embot::core
    ../../../../../../../../../icub-firmware-shared/embot/core/: embot_core.cpp embot_core_binary.cpp embot_core_utils.cpp
  group embot::hw
    ../../../../../embot/hw/: embot_hw_bsp.cpp embot_hw.cpp embot_hw_gpio.cpp embot_hw_led.cpp embot_hw_sys.cpp embot_hw_button.cpp embot_hw_can.cpp embot_hw_flash.cpp embot_hw_spi.cpp embot_hw_eth.cpp embot_hw_eeprom.cpp embot_hw_encoder.cpp embot_hw_timer.cpp embot_hw_chip_M95512DF.cpp embot_hw_chip_AS5045.cpp embot_hw_chip_MA730.cpp embot_hw_chip_MB049.cpp embot_hw_mtx.cpp embot_hw_icc_sig.cpp embot_hw_icc_mem.cpp embot_hw_icc_ltr.cpp embot_hw_icc_printer.cpp embot_hw_chip_KSZ8563.cpp
  group embot::hw::lowlevel
    ../../../../../embot/hw/: embot_hw_lowlevel.cpp
  group embot::hw::bsp
    ../../../bsp/ethdriver/: PHY_KSZ8563.c EMAC_STM32H7xx_KSZ8563.c ipal_hal_eth_stm32h7.c
    ../../../bsp/: embot_hw_button_bsp_amc.cpp embot_hw_can_bsp_amc.cpp embot_hw_eeprom_bsp_amc.cpp embot_hw_encoder_bsp_amc.cpp embot_hw_eth_bsp_amc.cpp embot_hw_flash_bsp_amc.cpp embot_hw_gpio_bsp_amc.cpp embot_hw_icc_bsp_amc.cpp embot_hw_i2c_bsp_amc.cpp embot_hw_led_bsp_amc.cpp embot_hw_mtx_bsp_amc.cpp embot_hw_spi_bsp_amc.cpp embot_hw_specialize_bsp_amc.cpp embot_hw_timer_bsp_amc.cpp embot_hw_testpoint_bsp_amc .cpp
  group HAL over embot::hw
    ../../../../../embot/hw/: hal_embot.cpp
  group embot::os
    ../../../../../embot/os/: embot_os.cpp embot_os_Action.cpp embot_os_theCallbackManager.cpp embot_os_theScheduler.cpp embot_os_theTimerManager.cpp embot_os_Thread.cpp embot_os_Timer.cpp embot_os_rtos.cpp
  group embot::os::EOM
    ../../../../../embot/os/: embot_os_eom.cpp
    ../../../../../embot/os/eom/: EOMmutex.embot.cpp EOMtask.embot.cpp
  group eo-core
    ../../../../../../../../../icub-firmware-shared/eth/embobj/core/core/: EOaction.c EOarray.c EoCommon.c EOconstarray.c EOconstvector.c EOdeque.c EOfifo.c EOlist.c EOpacket.c EOsm.c EOtheErrorManager.c EOtheMemoryPool.c EOtimer.c EOvector.c EOVmutex.c EOVtask.c EOVtheCallbackManager.c EOVtheSystem.c EOVtheTimerManager.c
  group eo-theIPnet
    ../../../../../embobj/plus/ipnet/: EOMtheIPnet.c EOsocket.c EOsocketDatagram.c EOVtheIPnet.c
  group eo-theEnvironment
    ../../../../../embobj/plus/embenv/: EOtheARMenvironment.c EOVtheEnvironment.c
    ../../../../../libs/highlevel/services/embenv/src/: eEsharedServices.c eEcommon.c shalBASE.c shalINFO.c shalPART.c
  group eo-updaterprotocol
    ../../../../../../../../../icub-firmware-shared/eth/embobj/plus/comm-v2/icub/: EoUpdaterProtocol.c
  group eo-ctrl-socket
    ../../../../../embobj/plus/ctrloop/: EOMtheEMSsocket.c EOMtheEMStransceiver.c
  group eo-transport
    ../../../../../../../../../icub-firmware-shared/eth/embobj/plus/comm-v2/transport/: EOtransceiver.c EOtheBOARDtransceiver.c EOtheInfoDispatcher.c EOtheParser.c EOtransmitter.c EOagent.c EOconfirmationManager.c EOnv.c EOnvSet.c EOproxy.c EOrop.c EOreceiver.c EOropframe.c EOtheFormer.c
  group eo-rop-protocol
    ../../../../../../../../../icub-firmware-shared/eth/embobj/plus/comm-v2/protocol/src/: EoProtocol.c EoProtocolAS_fun.c EoProtocolAS_rom.c EoProtocolEPs.c EoProtocolMC_fun.c EoProtocolMC_rom.c EoProtocolMN_fun.c EoProtocolMN_rom.c EoProtocolSK_fun.c EoProtocolSK_rom.c
  group eo-rop-protocol-callbacks
    ../cfg/protocol/rop/: EoProtocolMN_fun_amc.c EoProtocolMC_fun_amc.c EoProtocolAS_fun_amc.c
  group eo-state-idle [aka cfg]
    ../../../../../embobj/plus/ctrloop/: EOMtheEMSconfigurator.c
  group eo-state-fatalerror
    ../../../../../embobj/plus/ctrloop/: EOMtheEMSerror.c
  group eo-state-run
    ../../../../../embobj/plus/ctrloop/: EOMtheEMSrunner.c
  group eo-can-mapping+protocol+service
    ../../../../../embobj/plus/can/: EOtheCANmapping.c EOtheCANprotocol.c EOtheCANservice.c
  group eo-can-protocol-callbacks
    ../cfg/protocol/can/: EoCANprotASperiodic_amc.c EoCANprotASpolling_amc.c EoCANprotISperiodic_amc.c EoCANprotMCperiodic_amc.c EoCANprotMCpolling_amc.c EoCANprotSKperiodic_amc.c EoCANprotBSperiodic_amc.c
  group eo-services
    ../../../../../embobj/plus/board/: EOtheEntities.c
    ../../../../ems004/appl/v2/src/eoappservices/: EOtheCANdiscovery2.c
  group eo-appl-state-machine
    ../../../../../embobj/plus/ctrloop/: eOcfg_sm_EMSappl.c
  group eo-icub-fw-sha/icub
    ../../../../../../../../../icub-firmware-shared/eth/embobj/plus/comm-v2/icub/: EoManagement.c EoMotionControl.c EoAnalogSensors.c EoError.c EoBoards.c
  group embot::app::eth::theServices
    ../../../../../embot/app/eth/: embot_app_eth_Service.cpp embot_app_eth_theServices.cpp
    ../../../../ems004/appl/v2/src/eoappservices/: embot_app_eth_CANmonitor.cpp
  group embot::app::eth::theHandler
    ../../../../../embot/app/eth/: embot_app_eth_theHandler.cpp
    ../cfg/: theHandler_config.h
  group embot::app::scope
    ../../../../../../../../../icub-firmware-shared/embot/tools/: embot_tools.cpp
    ../../../../../embot/app/: embot_app_scope.cpp
  group embot::app::eth::theServiceMC
    ../../../../../embot/app/eth/: embot_app_eth_theServiceMC2.cpp embot_app_eth_Service_impl_mc_SERVICE.cpp embot_app_eth_Service_impl_mc_AGENTs.cpp embot_app_eth_Service_impl_mc_AGENTfoc.cpp embot_app_eth_Service_impl_mc_AGENTadvfoc.cpp embot_app_msg.cpp embot_app_eth_mc_messaging.cpp
    ../../../../../embot/prot/can/: embot_prot_can.cpp
  group eo-motor-controller
    ../../../../../embobj/plus/mc/: AbsEncoder.c Calibrators.c Controller.c Joint.c JointSet.c Motor.c Pid.c Trajectory.c WatchDog.c
  group mbd::kalman-filter
    ../../../../../mbd/kalman_filter/: kalman_filter.cpp kalman_filter_data.cpp
  group mbd::wrist-decoupler
    ../../../../../mbd/wrist_decoupler/: wrist_decoupler.cpp
  group embot::app::eth::theEncoderReader
    ../../../../../embot/app/eth/: embot_app_eth_theEncoderReader.cpp
  group embot::app::eth::theServiceFT
    ../../../../../embot/app/eth/: embot_app_eth_theServiceFT.cpp
    ../../../../ems004/appl/v2/src/eoappservices/: embot_app_eth_theFTservice.cpp
  group embot::app::eth::theICCservice
    ../../../../../embot/app/eth/: embot_app_eth_theICCservice.cpp embot_app_eth_theICCmapping.cpp embot_app_eth_theICCserviceCAN.cpp embot_app_eth_theICCserviceROP.cpp
  group embot::app::tester
    ../../../../ems004/appl/v2/src/eoappservices/: servicetester.cpp embot_app_eth_theServiceTester.cpp embot_app_eth_theMCserviceEOtesterconfig.cpp
  group mbd::torque-estimator
    ../../../../../mbd/torque_estimator/: TorqueEstimator.cpp
