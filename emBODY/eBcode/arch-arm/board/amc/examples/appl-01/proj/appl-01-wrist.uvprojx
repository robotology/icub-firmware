# Keil uVision project appl-01-wrist.uvprojx, settings and files
target amc-appl-01-osal-stlink (6180000::V6.18::ARMCLANG)
  device: STM32H745IIKx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.0
  cpu: IRAM(0x38000000,0x00010000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) XRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: amc +hex
  AfterMake: cmd.exe /C copy .\obj\amc.hex ..\bin\amc.hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: USE_EMBOT_HW EMBOBJ_USE_EMBOT USE_STM32HAL STM32HAL_BOARD_AMC STM32HAL_DRIVER_V1A0 WRIST_MK2
  c misc: -Wno-pragma-pack -Wno-deprecated-register -DEMBOT_USE_rtos_osal -DIPAL_use_cfg2 -DUSE_EMBOT_runner -DUSE_EMBOT_theHandler -DUSE_EMBOT_theServices -DEOTHESERVICES_disable_theMotionController -DUSE_EOtheMCamc -DUSE_EMBOT_theServicesMC
  c include: ..\..\..\..\..\libs\lowlevel\stm32hal\api;..\..\..\..\..\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\embot\hw;..\..\..\..\..\embot\os;..\..\..\..\..\embot\app;..\..\..\..\..\libs\midware\eventviewer\api;..\..\..\..\..\libs\highlevel\abslayer\ipal\api;--..\..\..\..\..\libs\highlevel\abslayer\hal2\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core;..\..\..\..\..\embobj\core\exec\multitask;..\..\..\..\..\embobj\plus\ipnet;..\src\emb-env;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\prot\eth;..\..\..\bsp;..\cfg;..\..\..\bsp\ethdriver;..\..\..\..\..\libs\highlevel\services\embenv\api;..\..\..\..\..\embobj\plus\embenv;..\..\..\..\..\libs\highlevel\abslayer\hal2\api;..\..\..\..\..\embobj\plus\ctrloop;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\icub;..\..\..\..\..\..\..\..\..\icub-firmware-shared\can\canProtocolLib;..\..\..\..\..\embot\app\eth;.;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\transport;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\protocol\api;..\cfg\protocol;..\..\..\..\..\embobj\plus\can;..\..\..\..\ems004\appl\v2\src\eoappservices;..\..\..\..\..\embobj\plus\board;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\tools;..\..\..\..\..\mbd\kalman_filter;..\..\..\..\..\embobj\plus\mc;..\..\..\..\..\libs\midware\hl-plus\api
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT9: RAM 0x38000000 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: ..\cfg\amc-template-appl.sct
  link misc: --diag_suppress=L6329
  group main
    ../src/: amc-appl-01.cpp
  group embot::app::eth
    ../../../../../embot/app/eth/: embot_app_eth_theApplication.cpp embot_app_eth_theIPnet.cpp embot_app_eth_theEnvironment.cpp embot_app_eth_theErrorManager.cpp embot_app_eth_theUpdaterParser.cpp embot_app_eth_theListener.cpp embot_app_eth_theBackdoor.cpp embot_app_eth_theETHmonitor.cpp
    ../../../../../embot/app/: embot_app_theLEDmanager.cpp
  group embot::app::eth::config
    ../cfg/: theApplication_config.h theApplication_config.cpp
  group stm32hal
    ../../../../../libs/lowlevel/stm32hal/lib/: stm32hal.h7.amc.v1A0.lib
    ../cfg/: startup_stm32h745xx_CM7.s
  group rtos
    ../../../../../libs/highlevel/abslayer/cmsisos2/lib/: cmsisos2.lib
    ../../../../../libs/highlevel/abslayer/osal/lib/: osal.cm4.dbg.lib osal.cm4.lib
    ../../../../../libs/midware/eventviewer/src/: eventviewer.c
  group ipal
    ../../../../../libs/highlevel/abslayer/ipal/lib/: ipal.lwip.h7.lib
    ../cfg/: ipal_cfg2.cpp
  group embot::core
    ../../../../../../../../../icub-firmware-shared/embot/core/: embot_core.cpp embot_core_binary.cpp embot_core_utils.cpp
  group embot::hw
    ../../../../../embot/hw/: embot_hw_bsp.cpp embot_hw.cpp embot_hw_gpio.cpp embot_hw_led.cpp embot_hw_lowlevel.cpp embot_hw_sys.cpp embot_hw_button.cpp embot_hw_can.cpp embot_hw_flash.cpp embot_hw_spi.cpp embot_hw_eth.cpp embot_hw_eeprom.cpp embot_hw_encoder.cpp embot_hw_timer.cpp embot_hw_chip_KSZ8563.cpp embot_hw_chip_M95512DF.cpp embot_hw_chip_AS5045.cpp embot_hw_chip_MA730.cpp embot_hw_chip_MB049.cpp embot_hw_mtx.cpp embot_hw_icc_sig.cpp embot_hw_icc_mem.cpp embot_hw_icc_ltr.cpp embot_hw_icc_printer.cpp
  group embot::hw::bsp
    ../../../bsp/: embot_hw_bsp_amc.cpp embot_hw_eth_bsp_amc.cpp embot_hw_mtx_bsp_amc.cpp embot_hw_icc_bsp_amc.cpp
    ../../../bsp/ethdriver/: PHY_KSZ8563.c EMAC_STM32H7xx_KSZ8563.c ipal_hal_eth_stm32h7.c
  group embot::os
    ../../../../../embot/os/: embot_os.cpp embot_os_Action.cpp embot_os_theCallbackManager.cpp embot_os_theScheduler.cpp embot_os_theTimerManager.cpp embot_os_Thread.cpp embot_os_Timer.cpp embot_os_rtos.cpp
  group embot::os::EOM
    ../../../../../embot/os/: embot_os_eom.cpp
    ../../../../../embot/os/eom/: EOMmutex.embot.cpp EOMtask.embot.cpp
  group eo-core
    ../../../../../../../../../icub-firmware-shared/eth/embobj/core/core/: EOaction.c EOarray.c EoCommon.c EOconstarray.c EOconstvector.c EOdeque.c EOfifo.c EOfifoByte.c EOfifoWord.c EOlist.c EOpacket.c EOsm.c EOtheErrorManager.c EOtheLEDpulser.c EOtheMemoryPool.c EOtimer.c EOumlsm.c EOvector.c EOVmutex.c EOVtask.c EOVtheCallbackManager.c EOVtheSystem.c EOVtheTimerManager.c
  group eo-theIPnet
    ../../../../../embobj/plus/ipnet/: EOMtheIPnet.c EOsocket.c EOsocketDatagram.c EOVtheIPnet.c
  group eo-theEnvironment
    ../../../../../embobj/plus/embenv/: EOtheARMenvironment.c EOVtheEnvironment.c
    ../../../../../libs/highlevel/services/embenv/src/: eEsharedServices.c eEcommon.c shalBASE.c shalINFO.c shalPART.c
  group eo-updaterprotocol
    ../../../../../../../../../icub-firmware-shared/eth/embobj/plus/comm-v2/icub/: EoUpdaterProtocol.c
  group ctrl-socket
    ../../../../../embobj/plus/ctrloop/: EOMtheEMSsocket.c EOMtheEMStransceiver.c
  group transport
    ../../../../../../../../../icub-firmware-shared/eth/embobj/plus/comm-v2/transport/: EOtransceiver.c EOtheBOARDtransceiver.c EOtheInfoDispatcher.c EOtheParser.c EOtransmitter.c EOagent.c EOconfirmationManager.c EOhostTransceiver.c EOnv.c EOnvSet.c EOproxy.c EOrop.c EOreceiver.c EOropframe.c EOtheFormer.c
  group eth-protocol
    ../../../../../../../../../icub-firmware-shared/eth/embobj/plus/comm-v2/protocol/src/: EoProtocol.c EoProtocolAS_fun.c EoProtocolAS_rom.c EoProtocolEPs.c EoProtocolMC_fun.c EoProtocolMC_rom.c EoProtocolMN_fun.c EoProtocolMN_rom.c EoProtocolSK_fun.c EoProtocolSK_rom.c
  group eth-protocol-callbacks
    ../cfg/protocol/: EoProtocolMN_fun_amc.c EoProtocolAS_fun_amc.c EoProtocolMC_fun_amc.c
  group brd-state-idle [former cfg]
    ../../../../../embobj/plus/ctrloop/: EOMtheEMSconfigurator.c
  group brd-state-fatalerror
    ../../../../../embobj/plus/ctrloop/: EOMtheEMSerror.c
  group brd-state-run
    ../../../../../embobj/plus/ctrloop/: EOMtheEMSrunner.c
  group can-protocol
    ../../../../../embobj/plus/can/: EOtheCANmapping.c EOtheCANprotocol.c EOtheCANservice.c
  group can-protocol-callbacks
    ../cfg/protocol/can/: EoCANprotASperiodic_amc.c EoCANprotASpolling_amc.c EoCANprotISperiodic_amc.c EoCANprotMCperiodic_amc.c EoCANprotMCpolling_amc.c EoCANprotSKperiodic_amc.c EoCANprotBSperiodic_amc.c
  group services
    ../../../../ems004/appl/v2/src/eoappservices/: embot_app_eth_CANmonitor.cpp embot_app_eth_theFTservice.cpp EOtheCANdiscovery2.c
    ../../../../../embobj/plus/board/: EOtheEntities.c
  group appl-sm
    ../../../../../embobj/plus/ctrloop/: eOcfg_sm_EMSappl.c
  group icub-fw-sha/icub
    ../../../../../../../../../icub-firmware-shared/eth/embobj/plus/comm-v2/icub/: EoError.c EoBoards.c EoManagement.c EoAnalogSensors.c
  group embot::app::eth-services
    ../../../../../embot/app/eth/: embot_app_eth_Service.cpp embot_app_eth_theServices.cpp embot_app_eth_theServiceFT.cpp
  group hal over embot::hw
    ../../../../../embot/hw/: hal_embot.cpp
  group theHandler
    ../../../../../embot/app/eth/: embot_app_eth_theHandler.cpp
    ../cfg/: theHandler_config.h
  group overridden
    ../cfg/overridden/: overridden_appl.cpp overridden_configurator.cpp overridden_error.c overridden_runner.cpp overridden_sm.cpp
  group scope
    ../../../../../embot/app/: embot_app_scope.cpp
    ../../../../../../../../../icub-firmware-shared/embot/tools/: embot_tools.cpp
  group mc-service
    ../../../../../embot/app/eth/: embot_app_eth_theServiceMC.cpp embot_app_eth_theEncoderReader.cpp EOtheMCamc.cpp
    ../../../../ems004/appl/v2/src/eoappservices/: EOtheMotionController.c
    ../../../../../../../../../icub-firmware-shared/eth/embobj/plus/comm-v2/icub/: EoMotionControl.c
  group mc-controller
    ../../../../../embobj/plus/mc/: AbsEncoder.c Calibrators.c Controller.c Joint.c JointSet.c Motor.c Pid.c Trajectory.c WatchDog.c wrist_decoupler.cpp wrist_decoupler_data.cpp
  group mbd::kalman-filter
    ../../../../../mbd/kalman_filter/: kalman_filter.cpp kalman_filter_data.cpp
target amc-appl-00-osal-segger (6180000::V6.18::ARMCLANG)
  device: STM32H745IIKx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.0
  cpu: as above
  output: h7eth +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: USE_EMBOT_HW EMBOBJ_USE_EMBOT USE_STM32HAL STM32HAL_BOARD_AMC STM32HAL_DRIVER_V1A0
  c misc: -Wno-pragma-pack -Wno-deprecated-register -DEMBOT_USE_rtos_osal -DIPAL_use_cfg2 -DUSE_EMBOT_runner -DUSE_EMBOT_theHandler -DUSE_EMBOT_theServices
  c include: ..\..\..\..\..\libs\lowlevel\stm32hal\api;..\..\..\..\..\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\embot\hw;..\..\..\..\..\embot\os;..\..\..\..\..\embot\app;..\..\..\..\..\libs\midware\eventviewer\api;..\..\..\..\..\libs\highlevel\abslayer\ipal\api;--..\..\..\..\..\libs\highlevel\abslayer\hal2\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core;..\..\..\..\..\embobj\core\exec\multitask;..\..\..\..\..\embobj\plus\ipnet;..\src\emb-env;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\prot\eth;..\..\..\bsp;..\cfg;..\..\..\bsp\ethdriver;..\..\..\..\..\libs\highlevel\services\embenv\api;..\..\..\..\..\embobj\plus\embenv;..\..\..\..\..\libs\highlevel\abslayer\hal2\api;..\..\..\..\..\embobj\plus\ctrloop;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\icub;..\..\..\..\..\..\..\..\..\icub-firmware-shared\can\canProtocolLib;..\..\..\..\..\embot\app\eth;.;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\transport;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\protocol\api;..\cfg\protocol;..\..\..\..\..\embobj\plus\can;..\..\..\..\ems004\appl\v2\src\eoappservices;..\..\..\..\..\embobj\plus\board
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT9: RAM 0x38000000 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: ..\cfg\amc-template-appl.sct
  link misc: --diag_suppress=L6329
target amc-appl-01-osal-ulpro (6180000::V6.18::ARMCLANG)
  device: STM32H745IIKx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.0
  cpu: as above
  output: h7eth +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: as above
  c misc: as above
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT9: RAM 0x38000000 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: ..\cfg\amc-template-appl.sct
  link misc: --diag_suppress=L6329
target ipnetdemo-cmsisos2-segger (6160000::V6.16::ARMCLANG)
  device: STM32H745IIKx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.0
  cpu: as above
  output: h7eth +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: USE_ZERO_OFFSET EMBOBJ_USE_EMBOT USE_STM32HAL STM32HAL_BOARD_AMC STM32HAL_DRIVER_V190
  c misc: -Wno-pragma-pack -Wno-deprecated-register -DEMBOT_USE_rtos_cmsisos2 -DIPAL_use_cfg2
  c include: ..\..\..\..\..\libs\lowlevel\stm32hal\api;..\..\..\..\..\libs\highlevel\abslayer\cmsisos2\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\embot\hw;..\..\..\..\..\embot\os;..\..\..\..\..\embot\app;..\..\..\..\..\embot\app;..\..\..\..\..\libs\midware\eventviewer\api;..\..\..\..\..\libs\highlevel\abslayer\ipal\api;..\..\..\..\..\libs\highlevel\abslayer\hal2\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core;..\..\..\..\..\embobj\core\exec\multitask;..\..\..\..\..\libs\highlevel\services\embenv\api;..\..\..\..\..\embobj\plus\ipnet;..\..\..\..\..\embobj\plus\embenv;..\src\emb-env;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\icub;..\..\..\..\..\..\..\..\..\icub-firmware-shared\can\canProtocolLib;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\prot\eth;..\..\..\bsp;..\..\bsp-ipal;..\cfg
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT9: RAM 0x38000000 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: ..\..\bsp-ipal\stm32h745xx_flash_CM7-udp.sct
  link misc: --diag_suppress=L6329
target ipnetdemo-cmsisos2-stlinkv3 (6160000::V6.16::ARMCLANG)
  device: STM32H745IIKx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.0
  cpu: as above
  output: h7eth +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: EMBOBJ_USE_EMBOT USE_STM32HAL STM32HAL_BOARD_AMC STM32HAL_DRIVER_V1A0
  c misc: as above
  c include: ..\..\..\..\..\libs\lowlevel\stm32hal\api;..\..\..\..\..\libs\highlevel\abslayer\cmsisos2\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\embot\hw;..\..\..\..\..\embot\os;..\..\..\..\..\embot\app;..\..\..\..\..\embot\app;..\..\..\..\..\libs\midware\eventviewer\api;..\..\..\..\..\libs\highlevel\abslayer\ipal\api;..\..\..\..\..\libs\highlevel\abslayer\hal2\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core;..\..\..\..\..\embobj\core\exec\multitask;..\..\..\..\..\libs\highlevel\services\embenv\api;..\..\..\..\..\embobj\plus\ipnet;..\..\..\..\..\embobj\plus\embenv;..\src\emb-env;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\icub;..\..\..\..\..\..\..\..\..\icub-firmware-shared\can\canProtocolLib;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\prot\eth;..\..\..\bsp;..\cfg;..\..\..\bsp\ethdriver
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT9: RAM 0x38000000 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\stm32h745xx_flash_CM7-udp.sct
  link misc: --diag_suppress=L6329
target ipnetdemo-osal-ulpro (6160000::V6.16::ARMCLANG)
  device: STM32H745IIKx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.0
  cpu: as above
  output: h7eth +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: as above
  c misc: -Wno-pragma-pack -Wno-deprecated-register -DEMBOT_USE_rtos_osal -DIPAL_use_cfg2
  c include: ..\..\..\..\..\libs\lowlevel\stm32hal\api;..\..\..\..\..\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\embot\hw;..\..\..\..\..\embot\os;..\..\..\..\..\embot\app;..\..\..\..\..\libs\midware\eventviewer\api;..\..\..\..\..\libs\highlevel\abslayer\ipal\api;--..\..\..\..\..\libs\highlevel\abslayer\hal2\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core;..\..\..\..\..\embobj\core\exec\multitask;..\..\..\..\..\embobj\plus\ipnet;..\src\emb-env;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\prot\eth;..\..\..\bsp;..\cfg;..\..\..\bsp\ethdriver
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT9: RAM 0x38000000 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\stm32h745xx_flash_CM7-udp.sct
  link misc: --diag_suppress=L6329
