# Keil uVision project amc-test-appl.uvprojx, settings and files
target amc-appl-test (6190000::V6.19::ARMCLANG)
  device: STM32H745IIKx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x38000000,0x00010000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) XRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: h7eth +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: USE_EMBOT_HW EMBOBJ_USE_EMBOT USE_STM32HAL STM32HAL_BOARD_AMC STM32HAL_DRIVER_V1A0
  c misc: -Wno-pragma-pack -Wno-deprecated-register -DEMBOT_USE_rtos_osal -DIPAL_use_cfg2 -DUSE_EMBOT_runner
  c include: ..\..\..\..\..\libs\lowlevel\stm32hal\api;..\..\..\..\..\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\embot\hw;..\..\..\..\..\embot\os;..\..\..\..\..\embot\app;..\..\..\..\..\libs\midware\eventviewer\api;..\..\..\..\..\libs\highlevel\abslayer\ipal\api;--..\..\..\..\..\libs\highlevel\abslayer\hal2\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core;..\..\..\..\..\embobj\core\exec\multitask;..\..\..\..\..\embobj\plus\ipnet;..\src\emb-env;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\prot\eth;..\..\..\bsp;..\cfg;..\..\..\bsp\ethdriver;..\..\..\..\..\libs\highlevel\services\embenv\api;..\..\..\..\..\embobj\plus\embenv;..\..\..\..\..\libs\highlevel\abslayer\hal2\api;..\..\..\..\..\embobj\plus\ctrloop;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\icub;..\..\..\..\..\..\..\..\..\icub-firmware-shared\can\canProtocolLib;..\..\..\..\..\embot\app\eth
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT9: RAM 0x38000000 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: ..\cfg\amc-template-appl.sct
  link misc: --diag_suppress=L6329
  group main
    ../src/: amc-appl-template-main.cpp
  group embot::app::eth
    ../../../../../embot/app/eth/: embot_app_eth_theApplication.cpp embot_app_eth_theIPnet.cpp embot_app_eth_theEnvironment.cpp embot_app_eth_theErrorManager.cpp embot_app_eth_theUpdaterParser.cpp embot_app_eth_theListener.cpp embot_app_eth_theBackdoor.cpp
    ../../../../../embot/app/: embot_app_theLEDmanager.cpp
  group embot::app::eth::config
    ../cfg/: theApplication_config.h theApplication_config.cpp
  group stm32hal
    ../../../../../libs/lowlevel/stm32hal/lib/: stm32hal.h7.amc.v1A0.lib
    ../cfg/: startup_stm32h745xx_CM7.s
  group rtos
    ../../../../../libs/highlevel/abslayer/cmsisos2/lib/: cmsisos2.lib
    ../../../../../libs/highlevel/abslayer/osal/lib/: osal.cm4.dbg.lib
    ../../../../../libs/midware/eventviewer/src/: eventviewer.c
  group ipal
    ../../../../../libs/highlevel/abslayer/ipal/lib/: ipal.lwip.h7.lib
    ../cfg/: ipal_cfg2.cpp
  group embot::core
    ../../../../../../../../../icub-firmware-shared/embot/core/: embot_core.cpp embot_core_binary.cpp embot_core_utils.cpp
  group embot::hw
    ../../../../../embot/hw/: embot_hw_bsp.cpp embot_hw.cpp embot_hw_gpio.cpp embot_hw_led.cpp embot_hw_sys.cpp embot_hw_button.cpp embot_hw_can.cpp embot_hw_flash.cpp embot_hw_spi.cpp embot_hw_eth.cpp embot_hw_chip_KSZ8563.cpp embot_hw_chip_M95512DF.cpp embot_hw_eeprom.cpp embot_hw_timer.cpp embot_hw_mtx.cpp embot_hw_icc_sig.cpp embot_hw_icc_mem.cpp embot_hw_icc_ltr.cpp embot_hw_icc_printer.cpp
  group embot::hw::bsp
    ../../../bsp/: embot_hw_bsp_amc.cpp embot_hw_eth_bsp_amc.cpp embot_hw_mtx_bsp_amc.cpp embot_hw_icc_bsp_amc.cpp
    ../../../bsp/ethdriver/: PHY_KSZ8563.c EMAC_STM32H7xx_KSZ8563.c ipal_hal_eth_stm32h7.c
  group embot::os
    ../../../../../embot/os/: embot_os.cpp embot_os_Action.cpp embot_os_theCallbackManager.cpp embot_os_theScheduler.cpp embot_os_theTimerManager.cpp embot_os_Thread.cpp embot_os_Timer.cpp embot_os_rtos.cpp
  group embot::os::EOM
    ../../../../../embot/os/: embot_os_eom.cpp
    ../../../../../embot/os/eom/: EOMmutex.embot.cpp EOMtask.embot.cpp
  group eo-core
    ../../../../../../../../../icub-firmware-shared/eth/embobj/core/core/: EOaction.c EOarray.c EoCommon.c EOconstarray.c EOconstvector.c EOdeque.c EOfifo.c EOfifoByte.c EOfifoWord.c EOlist.c EOpacket.c EOsm.c EOtheErrorManager.c EOtheLEDpulser.c EOtheMemoryPool.c EOtimer.c EOumlsm.c EOvector.c EOVmutex.c EOVtask.c EOVtheCallbackManager.c EOVtheSystem.c EOVtheTimerManager.c
  group eo-theIPnet
    ../../../../../embobj/plus/ipnet/: EOMtheIPnet.c EOsocket.c EOsocketDatagram.c EOVtheIPnet.c
  group eo-theEnvironment
    ../../../../../embobj/plus/embenv/: EOtheARMenvironment.c EOVtheEnvironment.c
    ../../../../../libs/highlevel/services/embenv/src/: eEsharedServices.c eEcommon.c shalBASE.c shalINFO.c shalPART.c
  group eo-updaterprotocol
    ../../../../../../../../../icub-firmware-shared/eth/embobj/plus/comm-v2/icub/: EoUpdaterProtocol.c
  group embot::hw::lowlevel
    ../../../../../embot/hw/: embot_hw_lowlevel.cpp
target ipnetdemo-cmsisos2-segger (6160000::V6.16::ARMCLANG)
  device: STM32H745IIKx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: as above
  output: h7eth +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: USE_ZERO_OFFSET EMBOBJ_USE_EMBOT USE_STM32HAL STM32HAL_BOARD_AMC STM32HAL_DRIVER_V190
  c misc: -Wno-pragma-pack -Wno-deprecated-register -DEMBOT_USE_rtos_cmsisos2 -DIPAL_use_cfg2
  c include: ..\..\..\..\..\libs\lowlevel\stm32hal\api;..\..\..\..\..\libs\highlevel\abslayer\cmsisos2\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\embot\hw;..\..\..\..\..\embot\os;..\..\..\..\..\embot\app;..\..\..\..\..\embot\app;..\..\..\..\..\libs\midware\eventviewer\api;..\..\..\..\..\libs\highlevel\abslayer\ipal\api;..\..\..\..\..\libs\highlevel\abslayer\hal2\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core;..\..\..\..\..\embobj\core\exec\multitask;..\..\..\..\..\libs\highlevel\services\embenv\api;..\..\..\..\..\embobj\plus\ipnet;..\..\..\..\..\embobj\plus\embenv;..\src\emb-env;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\icub;..\..\..\..\..\..\..\..\..\icub-firmware-shared\can\canProtocolLib;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\prot\eth;..\..\..\bsp;..\..\bsp-ipal;..\cfg
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT9: RAM 0x38000000 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: ..\..\bsp-ipal\stm32h745xx_flash_CM7-udp.sct
  link misc: --diag_suppress=L6329
target ipnetdemo-cmsisos2-stlinkv3 (6160000::V6.16::ARMCLANG)
  device: STM32H745IIKx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: as above
  output: h7eth +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: EMBOBJ_USE_EMBOT USE_STM32HAL STM32HAL_BOARD_AMC STM32HAL_DRIVER_V1A0
  c misc: as above
  c include: ..\..\..\..\..\libs\lowlevel\stm32hal\api;..\..\..\..\..\libs\highlevel\abslayer\cmsisos2\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\embot\hw;..\..\..\..\..\embot\os;..\..\..\..\..\embot\app;..\..\..\..\..\embot\app;..\..\..\..\..\libs\midware\eventviewer\api;..\..\..\..\..\libs\highlevel\abslayer\ipal\api;..\..\..\..\..\libs\highlevel\abslayer\hal2\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core;..\..\..\..\..\embobj\core\exec\multitask;..\..\..\..\..\libs\highlevel\services\embenv\api;..\..\..\..\..\embobj\plus\ipnet;..\..\..\..\..\embobj\plus\embenv;..\src\emb-env;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\icub;..\..\..\..\..\..\..\..\..\icub-firmware-shared\can\canProtocolLib;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\prot\eth;..\..\..\bsp;..\cfg;..\..\..\bsp\ethdriver
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT9: RAM 0x38000000 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\stm32h745xx_flash_CM7-udp.sct
  link misc: --diag_suppress=L6329
target ipnetdemo-osal-ulpro (6190000::V6.19::ARMCLANG)
  device: STM32H745IIKx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: as above
  output: h7eth +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: as above
  c misc: -Wno-pragma-pack -Wno-deprecated-register -DEMBOT_USE_rtos_osal -DIPAL_use_cfg2
  c include: ..\..\..\..\..\libs\lowlevel\stm32hal\api;..\..\..\..\..\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\embot\hw;..\..\..\..\..\embot\os;..\..\..\..\..\embot\app;..\..\..\..\..\libs\midware\eventviewer\api;..\..\..\..\..\libs\highlevel\abslayer\ipal\api;--..\..\..\..\..\libs\highlevel\abslayer\hal2\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core;..\..\..\..\..\embobj\core\exec\multitask;..\..\..\..\..\embobj\plus\ipnet;..\src\emb-env;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\prot\eth;..\..\..\bsp;..\cfg;..\..\..\bsp\ethdriver
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT9: RAM 0x38000000 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\stm32h745xx_flash_CM7-udp.sct
  link misc: --diag_suppress=L6329
