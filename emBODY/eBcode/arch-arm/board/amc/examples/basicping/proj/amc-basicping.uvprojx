# Keil uVision project amc-basicping.uvprojx, settings and files
target basicping-amc-segger (6160000::V6.16::ARMCLANG)
  device: STM32H745IIKx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.8.0
  cpu: IRAM(0x38000000,0x00010000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) XRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: g4eval +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: CORE_CM7 USE_HAL_DRIVER STM32H745xx USE_STM32HAL STM32HAL_BOARD_AMC STM32HAL_DRIVER_V1A0
  c misc: -Wno-pragma-pack -Wno-deprecated-register -DICUBTECH_USE_IPAL
  c include: ..\..\..\..\..\libs\lowlevel\stm32hal\api;..\..\..\..\..\libs\highlevel\abslayer\ipal\api;..\src;..\..\bsp-ipal;..\cfg;..\..\bsp-basic
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT9: RAM 0x38000000 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: ..\..\bsp-ipal\stm32h745xx_flash_CM7-udp.sct
  link misc: --diag_suppress=L6329
  group main
    ../src/: main-basicping.cpp
    ../../bsp-basic/: bsp_basic.cpp
  group stm32hal
    ../../../../../libs/lowlevel/stm32hal/lib/: stm32hal.h7.amc.v1A0.lib
  group stm32hal-config
    ../cfg/: startup_stm32h745xx_CM7.s
  group ipal-h7-lib
    ../../../../../libs/highlevel/abslayer/ipal/lib/: ipal.lwip.h7.lib
  group ipal-h7-cfg
    ../cfg/: ipal_cfg2.cpp
  group bsp-ipal
    ../../../bsp/ethdriver/: PHY_KSZ8563.c ipal_hal_eth_stm32h7.c EMAC_STM32H7xx_KSZ8563.c stm32h7xx_ethirqhandler.c
target basicping-amc-stlinkv3 (6160000::V6.16::ARMCLANG)
  device: STM32H745IIKx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.8.0
  cpu: as above
  output: g4eval +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: as above
  c misc: as above
  c include: ..\..\..\..\..\libs\lowlevel\stm32hal\api;..\..\..\..\..\libs\highlevel\abslayer\ipal\api;..\src;..\cfg;..\..\bsp-basic;..\..\..\bsp\ethdriver
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT9: RAM 0x38000000 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: ..\..\..\bsp\ethdriver\stm32h745xx_flash_CM7-udp.sct
  link misc: --diag_suppress=L6329
target basicping-amc-ulpro (6160000::V6.16::ARMCLANG)
  device: STM32H745IIKx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.8.0
  cpu: as above
  output: g4eval +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: as above
  c misc: as above
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT9: RAM 0x38000000 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: ..\..\..\bsp\ethdriver\stm32h745xx_flash_CM7-udp.sct
  link misc: --diag_suppress=L6329
