# Keil uVision project amc.test.i2c.uvprojx, settings and files
target test-ulpro (6190000::V6.19::ARMCLANG)
  device: STM32H745IIKx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x38000000,0x00010000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) XRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: amc +hex
  AfterMake: cmd.exe /C copy .\obj\amc.hex ..\bin\amc.hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: USE_EMBOT_HW USE_STM32HAL STM32HAL_BOARD_AMC STM32HAL_DRIVER_V1A0 EMBOT_USE_rtos_osa
  c misc: -Wno-pragma-pack -Wno-deprecated-register -DEMBOBJ_USE_EMBOT  -DEMBOT_USE_rtos_osal -DIPAL_use_cfg2
  c include: ..\..\..\..\..\libs\lowlevel\stm32hal\api;..\..\..\..\..\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\embot\hw;..\..\..\..\..\embot\os;..\..\..\..\..\embot\app;..\..\..\..\..\libs\midware\eventviewer\api;..\cfg;..\..\..\..\..\embot\app\eth;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\tools;..\src;.;.;..\..\..\..\..\embot\prot\can;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\icub;..\..\..\..\..\..\..\..\..\icub-firmware-shared\can\canProtocolLib;..\..\..\bsp;..\..\..\..\..\libs\highlevel\abslayer\ipal\api;..\..\..\bsp\ethdriver;.\for-ipnet;..\..\..\..\..\embobj\plus\ipnet;..\..\..\..\..\embobj\core\exec\multitask
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT9: RAM 0x38000000 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: ..\cfg\amc-template-appl.sct
  link misc: --diag_suppress=L6329
  group main
    ../src/: amc_test_main.cpp
  group embot::app
    ../../../../../embot/app/: embot_app_theLEDmanager.cpp embot_app_scope.cpp
    ../../../../../embot/app/eth/: embot_app_eth_theErrorManager.cpp
    ../../../../../../../../../icub-firmware-shared/embot/tools/: embot_tools.cpp
  group stm32hal
    ../../../../../libs/lowlevel/stm32hal/lib/: stm32hal.h7.amc.v1A0.lib
    ../cfg/: startup_stm32h745xx_CM7.s
  group rtos
    ../../../../../libs/highlevel/abslayer/osal/lib/: osal.cm4.dbg.lib osal.cm4.lib
    ../../../../../libs/midware/eventviewer/src/: eventviewer.c
  group embot::core
    ../../../../../../../../../icub-firmware-shared/embot/core/: embot_core.cpp embot_core_binary.cpp embot_core_utils.cpp
  group embot::hw-core
    ../../../../../embot/hw/: embot_hw.cpp embot_hw_sys.cpp embot_hw_bsp.cpp
  group embot::hw::lowlevel
    ../../../../../embot/hw/: embot_hw_lowlevel.cpp
  group embot::hw-extra
    ../../../../../embot/hw/: embot_hw_gpio.cpp embot_hw_led.cpp embot_hw_can.cpp embot_hw_flash.cpp embot_hw_spi.cpp embot_hw_eeprom.cpp embot_hw_encoder.cpp embot_hw_timer.cpp embot_hw_chip_MB049.cpp embot_hw_chip_MA730.cpp embot_hw_chip_AS5045.cpp embot_hw_chip_M95512DF.cpp embot_hw_button.cpp embot_hw_icc_ltr.cpp embot_hw_icc_mem.cpp embot_hw_icc_sig.cpp embot_hw_mtx.cpp embot_hw_icc_printer.cpp embot_hw_chip_KSZ8563.cpp embot_hw_eth.cpp embot_hw_i2c.cpp embot_hw_tlv493d.cpp
  group embot::hw::bsp-minimal
    ../bsp.minimal/: embot_hw_bsp_amc_minimal.cpp embot_hw_mtx_bsp_amc.cpp embot_hw_icc_bsp_amc.cpp
  group embot::hw::bsp
    ../../../bsp/: embot_hw_bsp_amc.cpp embot_hw_eth_bsp_amc.cpp embot_hw_icc_bsp_amc.cpp embot_hw_mtx_bsp_amc.cpp
  group embot::hw::bsp::eth
    ../../../bsp/ethdriver/: EMAC_STM32H7xx_KSZ8563.c ipal_hal_eth_stm32h7.c PHY_KSZ8563.c
  group embot::os
    ../../../../../embot/os/: embot_os.cpp embot_os_Action.cpp embot_os_theCallbackManager.cpp embot_os_theScheduler.cpp embot_os_theTimerManager.cpp embot_os_Thread.cpp embot_os_Timer.cpp embot_os_rtos.cpp
  group test
    ../src/: test.cpp
  group udp-theIPnet
    ../../../../../embot/app/eth/: embot_app_eth_theIPnet.cpp
    ../../../../../libs/highlevel/abslayer/ipal/lib/: ipal.lwip.h7.lib
    ../cfg/: ipal_cfg2.cpp
    ../../../../../embobj/plus/ipnet/: EOMtheIPnet.c EOsocket.c EOsocketDatagram.c EOVtheIPnet.c
  group udp-needs-embot::os::EOM
    ../../../../../embot/os/: embot_os_eom.cpp
    ../../../../../embot/os/eom/: EOMmutex.embot.cpp EOMtask.embot.cpp
  group udp-needs-eo-core
    ../../../../../../../../../icub-firmware-shared/eth/embobj/core/core/: EoCommon.c EOtheErrorManager.c EOtimer.c EOaction.c EOpacket.c EOlist.c EOfifo.c EOVtask.c EOVtheCallbackManager.c EOVmutex.c EOtheMemoryPool.c EOVtheSystem.c EOVtheTimerManager.c EOdeque.c
  group theBackdoor
    ../../../../../embot/app/eth/: embot_app_eth_theBackdoor.cpp
target test-stlink (6190000::V6.19::ARMCLANG)
  device: STM32H745IIKx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: as above
  output: amc +hex
  AfterMake: cmd.exe /C copy .\obj\amc.hex ..\bin\amc.hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: as above
  c misc: -Wno-pragma-pack -Wno-deprecated-register
  c include: ..\..\..\..\..\libs\lowlevel\stm32hal\api;..\..\..\..\..\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\embot\hw;..\..\..\..\..\embot\os;..\..\..\..\..\embot\app;..\..\..\..\..\libs\midware\eventviewer\api;..\cfg;..\..\..\..\..\embot\app\eth;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\tools;..\bsp.minimal;..\src;.;.;..\..\..\..\..\embot\prot\can
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT9: RAM 0x38000000 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: ..\cfg\amc-template-appl.sct
  link misc: --diag_suppress=L6329
