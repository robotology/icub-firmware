# Keil uVision project amc2c-appl-icc.uvprojx, settings and files
target appl-can-stlink (6190000::V6.19::ARMCLANG)
  device: STM32H745IIKx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x10000000,0x00048000) IROM(0x08100000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: amc2c +hex
  c flags: Optim=5 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_AMC2C STM32HAL_DRIVER_V1A0
  c misc: -Wno-pragma-pack -Wno-deprecated-register -DEMBOT_USE_rtos_osal
  c include: ..\..\..\..\libs\lowlevel\stm32hal\api;..\..\..\..\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\embot\hw;..\..\..\..\embot\os;..\..\..\..\embot\app;..\..\..\..\embot\app;..\..\..\..\libs\midware\eventviewer\api;..\..\..\..\libs\highlevel\services\embenv\api;..\..\..\..\embot\prot\can;..\..\..\..\..\..\..\..\icub-firmware-shared\can\canProtocolLib;..\..\..\..\..\..\..\..\icub-firmware-shared\embot\tools;..\..\bsp;..\..\..\..\embot\app\eth;..\..\..\..\embot\app\bldc;..\src\app-board-amc2c;..\src\model-based-design\sharedutils;..\src\model-based-design\can-decoder;..\src\model-based-design\can-encoder;..\src\model-based-design\supervisor-rx;..\src\model-based-design\supervisor-tx;..\src\model-based-design\control-outer;..\src\model-based-design\control-foc;..\src\model-based-design\estimator;..\src\model-based-design\amc-bldc;..\src\model-based-design\filter-current;..\src\model-based-design\thermal-model;..\..\..\..\libs\lowlevel\cmsis\dsp\v160\Include;..\..\bsp\motorhal
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x48000
  scatter file: ..\cfg\amc2c-template-appl.sct
  link misc: --diag_suppress=L6329
  group main
    ../src/: amc2c-main2.cpp
  group embot::app::board::amc2c
    ../src/app-board-amc2c/: embot_app_board_amc2c_info.cpp embot_app_board_amc2c_mbd.icc.cpp embot_app_board_amc2c_theCANagentCORE.cpp
  group theMBD
    ../src/app-board-amc2c/: embot_app_board_amc2c_theMBD.cpp
  group embot::app::bldc
    ../../../../embot/app/eth/: embot_app_eth_theICCservice.cpp
    ../../../../embot/app/bldc/: embot_app_bldc_theCOMMicc.cpp embot_app_bldc_theApplication.cpp embot_app_bldc_theCTRL.cpp embot_app_bldc_theMSGbroker.cpp
  group embot::app::application
    ../../../../embot/app/: embot_app_theLEDmanager.cpp embot_app_application_theCANparserCORE.cpp embot_app_application_theCANtracer.cpp embot_app_scope.cpp
  group stm32hal
    ../../../../libs/lowlevel/stm32hal/lib/: stm32hal.h7.amc2c.v1A0.lib
    ../cfg/: stm32hal.h7.startup.amc.CM4.s
  group rtos
    ../../../../libs/highlevel/abslayer/osal/lib/: osal.cm4.dbg.lib
    ../../../../libs/midware/eventviewer/src/: eventviewer.c
  group embot::core
    ../../../../../../../../icub-firmware-shared/embot/core/: embot_core.cpp embot_core_binary.cpp
  group embot::tools
    ../../../../../../../../icub-firmware-shared/embot/tools/: embot_tools.cpp
  group embot::hw
    ../../../../embot/hw/: embot_hw.cpp embot_hw_bsp.cpp embot_hw_gpio.cpp embot_hw_led.cpp embot_hw_sys.cpp embot_hw_button.cpp embot_hw_can.cpp embot_hw_flash.cpp embot_hw_timer.cpp embot_hw_types.cpp embot_hw_motor.cpp embot_hw_testpoint.cpp embot_hw_mtx.cpp embot_hw_icc_sig.cpp embot_hw_icc_mem.cpp embot_hw_icc_ltr.cpp embot_hw_icc_printer.cpp
  group embot::hw::lowlevel-0optimized
    ../../../../embot/hw/: embot_hw_lowlevel.cpp
  group embot::hw::bsp
    ../../bsp/: embot_hw_bsp_amc2c.cpp embot_hw_can_bsp_amc2c.cpp embot_hw_flash_bsp_amc2c.cpp embot_hw_timer_bsp_amc2c.cpp embot_hw_motor_bsp_amc2c.cpp embot_hw_mtx_bsp_amc2c.cpp embot_hw_icc_bsp_amc2c.cpp
  group motorhal
    ../../bsp/motorhal/: motorhal.cpp motorhal_config.c adcm.c enc.c hall.c pwm.c motorhal_faults.c
  group embot::os
    ../../../../embot/os/: embot_os.cpp embot_os_Action.cpp embot_os_theCallbackManager.cpp embot_os_theScheduler.cpp embot_os_theTimerManager.cpp embot_os_Thread.cpp embot_os_Timer.cpp embot_os_rtos.cpp
  group embot::prot::can
    ../../../../embot/prot/can/: embot_prot_can.cpp embot_prot_can_analog_periodic.cpp embot_prot_can_analog_polling.cpp embot_prot_can_bootloader.cpp embot_prot_can_inertial_periodic.cpp embot_prot_can_motor_periodic.cpp embot_prot_can_motor_polling.cpp embot_prot_can_skin_periodic.cpp
  group others-cmsis-math
    ../../../../libs/lowlevel/cmsis/dsp/v160/Lib/ARM/: arm_cortexM4lf_math.lib
  group mbd
    ../src/model-based-design/sharedutils/: const_params.cpp rt_hypotf_snf.cpp rt_nonfinite.cpp rt_roundd_snf.cpp rtGetInf.cpp rtGetNaN.cpp uMultiWord2Double.cpp uMultiWordShl.cpp rtw_enable_disable_motors.c rtw_motor_config.c rt_roundf_snf.cpp
  group mbd::can-encoder
    ../src/model-based-design/can-encoder/: can_encoder.cpp
  group mbd::can-decoder
    ../src/model-based-design/can-decoder/: can_decoder.cpp
  group mbd::supervisor-rx
    ../src/model-based-design/supervisor-rx/: SupervisorFSM_RX.cpp SupervisorFSM_RX_data.cpp
  group mbd::supervisor-tx
    ../src/model-based-design/supervisor-tx/: SupervisorFSM_TX.cpp
  group mbd::control-outer
    ../src/model-based-design/control-outer/: control_outer.cpp
  group mbd::control-foc
    ../src/model-based-design/control-foc/: control_foc.cpp control_foc_data.cpp FOCInnerLoop.cpp
  group mdb::estimator
    ../src/model-based-design/estimator/: estimation_velocity.cpp
  group mbd::filter-current
    ../src/model-based-design/filter-current/: filter_current.cpp
  group mbd::amc-bldc
    ../src/model-based-design/amc-bldc/: AMC_BLDC.cpp
  group mbd::thermal-model
    ../src/model-based-design/thermal-model/: thermal_model.cpp
target appl-icc-ulpro (6190000::V6.19::ARMCLANG)
  device: STM32H745IIKx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: as above
  output: amc2c_icc +hex
  AfterMake: cmd.exe /C copy .\obj\amc2c_icc.hex ..\bin\amc2c.icc.hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: xTEST_theICCservice USE_STM32HAL STM32HAL_BOARD_AMC2C STM32HAL_DRIVER_V1A0
  c misc: -Wno-pragma-pack -Wno-deprecated-register -DEMBOT_USE_rtos_osal -DuseICC
  c include: ..\..\..\..\libs\lowlevel\stm32hal\api;..\..\..\..\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\embot\hw;..\..\..\..\embot\os;..\..\..\..\embot\app;..\..\..\..\embot\app;..\..\..\..\libs\midware\eventviewer\api;..\..\..\..\libs\highlevel\services\embenv\api;..\..\..\..\embot\prot\can;..\..\..\..\..\..\..\..\icub-firmware-shared\can\canProtocolLib;..\..\..\..\..\..\..\..\icub-firmware-shared\embot\tools;..\..\bsp;..\..\..\..\embot\app\eth;..\..\..\..\embot\app\bldc;..\src\app-board-amc2c;..\src\model-based-design\sharedutils;..\src\model-based-design\can-decoder;..\src\model-based-design\can-encoder;..\src\model-based-design\supervisor-rx;..\src\model-based-design\supervisor-tx;..\src\model-based-design\control-outer;..\src\model-based-design\control-foc;..\src\model-based-design\estimator;..\src\model-based-design\amc-bldc;..\src\model-based-design\filter-current;..\src\model-based-design\thermal-model;..\..\..\..\libs\lowlevel\cmsis\dsp\v160\Include;..\..\bsp\motorhal;..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\icub;..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x48000
  scatter file: ..\cfg\amc2c-template-appl.sct
  link misc: --diag_suppress=L6329
target appl-can-ulpro-test (6180000::V6.18::ARMCLANG)
  device: STM32H745IIKx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: as above
  output: amc2c +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_AMC2C STM32HAL_DRIVER_V1A0 MOTORHALCONFIG_enabletests
  c misc: as above
  c include: ..\..\..\..\libs\lowlevel\stm32hal\api;..\..\..\..\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\embot\hw;..\..\..\..\embot\os;..\..\..\..\embot\app;..\..\..\..\embot\app;..\..\..\..\libs\midware\eventviewer\api;..\..\..\..\libs\highlevel\services\embenv\api;..\..\..\..\embot\prot\can;..\..\..\..\..\..\..\..\icub-firmware-shared\can\canProtocolLib;..\..\..\..\..\..\..\..\icub-firmware-shared\embot\tools;..\..\bsp;..\..\..\..\embot\app\eth;..\..\..\..\embot\app\bldc;..\src\app-board-amc2c;..\src\model-based-design\sharedutils;..\src\model-based-design\can-decoder;..\src\model-based-design\can-encoder;..\src\model-based-design\supervisor-rx;..\src\model-based-design\supervisor-tx;..\src\model-based-design\control-outer;..\src\model-based-design\control-foc;..\src\model-based-design\estimator;..\src\model-based-design\amc-bldc;..\src\model-based-design\filter-current;..\..\..\..\libs\lowlevel\cmsis\dsp\v160\Include;..\..\bsp\motorhal
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x48000
  scatter file: ..\cfg\amc2c-template-appl.sct
  link misc: --diag_suppress=L6329
