# Keil uVision project amc2c.test.icc.uvprojx, settings and files
target test-ulpro (6190000::V6.19::ARMCLANG)
  device: STM32H745IIKx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x10000000,0x00048000) IROM(0x08100000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: amc2c +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_AMC2C STM32HAL_DRIVER_V1A0
  c misc: -Wno-pragma-pack -Wno-deprecated-register -DEMBOT_USE_rtos_osal
  c include: ..\..\..\..\..\libs\lowlevel\stm32hal\api;..\..\..\..\..\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\embot\hw;..\..\..\..\..\embot\os;..\..\..\..\..\embot\app;..\..\..\..\..\embot\app;..\..\..\..\..\libs\midware\eventviewer\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\tools;..\..\..\bsp;..\..\..\..\..\embot\app\eth;..\..\..\..\..\embot\app\bldc;..\src\app-board-amc2c;..\..\..\bsp\motorhal;..\..\..\..\..\embot\prot\can;..\cfg;.;.;..\..\..\..\..\embot\app\eth;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\icub;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core;..\..\..\..\..\..\..\..\..\icub-firmware-shared\can\canProtocolLib
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x48000
  scatter file: ..\cfg\amc2c-template-appl.sct
  link misc: --diag_suppress=L6329
  group main
    ../src/: amc2c-main2.cpp
  group embot::app::application
    ../../../../../embot/app/: embot_app_theLEDmanager.cpp embot_app_scope.cpp
    ../../../../../embot/app/eth/: embot_app_eth_theErrorManager.cpp
  group stm32hal
    ../../../../../libs/lowlevel/stm32hal/lib/: stm32hal.h7.amc2c.v1A0.lib
    ../cfg/: stm32hal.h7.startup.amc.CM4.s
  group rtos
    ../../../../../libs/highlevel/abslayer/osal/lib/: osal.cm4.dbg.lib
    ../../../../../libs/midware/eventviewer/src/: eventviewer.c
  group embot::core
    ../../../../../../../../../icub-firmware-shared/embot/core/: embot_core.cpp embot_core_binary.cpp
  group embot::tools
    ../../../../../../../../../icub-firmware-shared/embot/tools/: embot_tools.cpp
  group embot::hw
    ../../../../../embot/hw/: embot_hw.cpp embot_hw_bsp.cpp embot_hw_gpio.cpp embot_hw_led.cpp embot_hw_sys.cpp embot_hw_button.cpp embot_hw_can.cpp embot_hw_flash.cpp embot_hw_timer.cpp embot_hw_types.cpp embot_hw_motor.cpp embot_hw_testpoint.cpp embot_hw_mtx.cpp embot_hw_icc_sig.cpp embot_hw_icc_mem.cpp embot_hw_icc_ltr.cpp embot_hw_icc_printer.cpp
  group embot::hw::lowlevel-0optimized
    ../../../../../embot/hw/: embot_hw_lowlevel.cpp
  group embot::hw::bsp
    ../../../bsp/: embot_hw_bsp_amc2c.cpp embot_hw_can_bsp_amc2c.cpp embot_hw_flash_bsp_amc2c.cpp embot_hw_timer_bsp_amc2c.cpp embot_hw_motor_bsp_amc2c.cpp embot_hw_mtx_bsp_amc2c.cpp embot_hw_icc_bsp_amc2c.cpp
  group embot::os
    ../../../../../embot/os/: embot_os.cpp embot_os_Action.cpp embot_os_theCallbackManager.cpp embot_os_theScheduler.cpp embot_os_theTimerManager.cpp embot_os_Thread.cpp embot_os_Timer.cpp embot_os_rtos.cpp
  group others::motorhal
    ../../../bsp/motorhal/: motorhal.cpp motorhal_config.c adcm.c enc.c hall.c pwm.c motorhal_faults.c
  group test
    ../src/: test.cpp
    ../../../../../embot/app/eth/: embot_app_eth_theICCservice.cpp
