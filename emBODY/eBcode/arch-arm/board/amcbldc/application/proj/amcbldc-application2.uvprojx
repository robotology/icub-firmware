# Keil uVision project amcbldc-application2.uvprojx, settings and files
target amcbldc-app-motorhal2 (6220000::V6.22::ARMCLANG)
  device: STM32G474QETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.6.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: amcbldc +hex
  AfterMake: cmd.exe /C copy .\Obj\amcbldc.hex ..\bin\amcbldc.hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_AMCBLDC STM32HAL_DRIVER_V122
  c misc: -Wno-pragma-pack -Wno-deprecated-register -DEMBOT_USE_rtos_osal -DEMBOT_AMCBLDC_APP05
  c include: ..\..\bsp;..\..\..\..\libs\highlevel\abslayer\osal\api;..\..\..\..\libs\midware\eventviewer\api;..\..\..\..\libs\lowlevel\stm32hal\api;..\..\..\..\embot\app;..\..\..\..\embot\i2h;..\..\..\..\embot\hw;..\..\..\..\embot\os;..\..\..\..\embot;..\..\..\..\embot\app\dsp;..\..\..\..\embot\app\skeleton;..\..\..\..\embot\prot\can;..\..\..\..\..\..\..\..\icub-firmware-shared\can\canProtocolLib;..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\..\..\..\icub-firmware-shared\embot\tools;..\..\..\..\libs\highlevel\abslayer\hal2\api;..\src\motorhal2;..\..\..\..\mbd\amcbldc\sharedutils;..\..\..\..\mbd\amcbldc\can-decoder;..\..\..\..\mbd\amcbldc\can-raw2struct;..\..\..\..\mbd\amcbldc\motion-controller-single;..\..\..\..\mbd\amcbldc\motion-controller;..\..\..\..\mbd\amcbldc\supervisor;..\..\..\..\mbd\amcbldc\supervisor-tx;..\..\..\..\mbd\amcbldc\can-encoder;..\..\..\..\mbd\amcbldc\control-outer;..\..\..\..\mbd\amcbldc\control-foc;..\..\..\..\mbd\amcbldc\estimator;..\..\..\..\mbd\amcbldc\amc-bldc;..\..\..\..\mbd\amcbldc\filter-current;..\..\..\..\embot\app\bldc;..\src\app-board-amcbldc;..\..\..\..\embot\app;..\..\..\..\embot\app\eth
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\amcbldc-application.sct
  link misc: --diag_suppress=L6329
  group main
    ../src/: amcbldc-main2.cpp
  group embot::app::board::amcbldc
    ../src/app-board-amcbldc/: embot_app_board_amcbldc_info.cpp embot_app_board_amcbldc_MBD.cpp embot_app_board_amcbldc_MBD.demo.cpp embot_app_board_amcbldc_theMBD.cpp
  group embot::app::bldc
    ../../../../embot/app/bldc/: embot_app_bldc_theMSGbroker.cpp embot_app_bldc_theCOMM.cpp embot_app_bldc_theCTRL.cpp embot_app_bldc_theApplication.cpp
  group embot::app::application
    ../../../../embot/app/: embot_app_scope.cpp embot_app_theLEDmanager.cpp embot_app_application_theCANagentCORE.cpp embot_app_application_theCANparserCORE.cpp
    ../../../../../../eBcode/arch-arm/embot/app/: embot_app_application_theCANtracer.cpp
  group stm32hal
    ../../../../libs/lowlevel/stm32hal/lib/: stm32hal.g4.v120.amcbldc.lib stm32hal.g4.v122.amcbldc.lib
    ../cfg/: stm32hal.startup.amcbldc.s
  group rtos
    ../../../../../../eBcode/arch-arm/libs/highlevel/abslayer/osal/lib/: osal.cm4.dbg.lib
    ../../../../../../eBcode/arch-arm/libs/midware/eventviewer/src/: eventviewer.c
  group embot::core
    ../../../../../../../../icub-firmware-shared/embot/core/: embot_core.cpp embot_core_binary.cpp
  group embot::tools
    ../../../../../../../../icub-firmware-shared/embot/tools/: embot_tools.cpp
  group embot::hw
    ../../../../../../eBcode/arch-arm/embot/hw/: embot_hw_flash.cpp embot_hw.cpp embot_hw_bsp.cpp embot_hw_sys.cpp embot_hw_can.cpp embot_hw_timer.cpp embot_hw_gpio.cpp embot_hw_led.cpp embot_hw_button.cpp
    ../../../../embot/hw/: embot_hw_types.cpp embot_hw_motor.cpp
  group embot::hw::lowlevel-0optimized
    ../../../../embot/hw/: embot_hw_lowlevel.cpp
  group embot::hw::bsp
    ../../bsp/: embot_hw_bsp_amcbldc.cpp
    ./: embot_hw_analog_bsp_amcbldc.cpp
  group embot<flash stored info>
    ../../../../../../eBcode/arch-arm/embot/hw/: embot_hw_FlashStorage.cpp
    ../../../../../../eBcode/arch-arm/embot/app/: embot_app_theCANboardInfo.cpp
  group embot::os
    ../../../../../../eBcode/arch-arm/embot/os/: embot_os.cpp embot_os_Thread.cpp embot_os_theCallbackManager.cpp embot_os_theScheduler.cpp embot_os_theTimerManager.cpp embot_os_Timer.cpp
    ../../../../embot/os/: embot_os_Action.cpp embot_os_rtos.cpp
  group embot::prot::can
    ../../../../../../eBcode/arch-arm/embot/prot/can/: embot_prot_can.cpp embot_prot_can_inertial_periodic.cpp embot_prot_can_motor_polling.cpp embot_prot_can_motor_periodic.cpp embot_prot_can_bootloader.cpp embot_prot_can_analog_polling.cpp embot_prot_can_analog_periodic.cpp
  group others::motorhal
    ../src/motorhal/: motorhal_config.c encoder.c pwm.c analog.c motorhal_faults.c
  group others::motorhal2
    ../src/motorhal2/: motorhal_config.c encoder.c pwm.c analog.c motorhal_faults.c
  group mbd
    ../../../../mbd/amcbldc/sharedutils/: const_params.cpp rtw_motor_config.c rtw_enable_disable_motors.c rt_hypotf.cpp rt_roundf.cpp
  group mbd::can-encoder
    ../../../../mbd/amcbldc/can-encoder/: can_encoder.cpp
  group mbd::can-decoder
    ../../../../mbd/amcbldc/can-decoder/: can_decoder.cpp
  group mbd::supervisor
    ../../../../mbd/amcbldc/supervisor/: supervisor.cpp
  group mbd::supervisor-tx
    ../../../../mbd/amcbldc/supervisor-tx/: SupervisorFSM_TX.cpp
  group mbd::control-outer
    ../../../../mbd/amcbldc/control-outer/: control_outer.cpp
  group mbd::control-foc
    ../../../../mbd/amcbldc/control-foc/: control_foc.cpp FOCInnerLoop.cpp
  group mdb::estimator
    ../../../../mbd/amcbldc/estimator/: estimation_velocity.cpp
  group mbd::filter-current
    ../../../../mbd/amcbldc/filter-current/: filter_current.cpp
  group mbd::amc-bldc
    ../../../../mbd/amcbldc/amc-bldc/: AMC_BLDC.cpp
  group mbd::motion-controller
    ../../../../mbd/amcbldc/motion-controller-single/: motion_controller_single.cpp
    ../../../../mbd/amcbldc/motion-controller/: motion_controller.cpp motion_controller_data.cpp
target amcbldc-app-motorhal1 (6190000::V6.19::ARMCLANG)
  device: STM32G474QETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.6.0
  cpu: as above
  output: amcbldc +hex
  AfterMake: cmd.exe /C copy .\Obj\amcbldc.hex ..\bin\amcbldc.hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_AMCBLDC STM32HAL_DRIVER_V120
  c misc: as above
  c include: ..\..\bsp;..\..\..\..\libs\highlevel\abslayer\osal\api;..\..\..\..\libs\midware\eventviewer\api;..\..\..\..\libs\lowlevel\stm32hal\api;..\..\..\..\embot\app;..\..\..\..\embot\i2h;..\..\..\..\embot\hw;..\..\..\..\embot\os;..\..\..\..\embot;..\..\..\..\embot\app\dsp;..\..\..\..\embot\app\skeleton;..\..\..\..\embot\prot\can;..\..\..\..\..\..\..\..\icub-firmware-shared\can\canProtocolLib;..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\..\..\..\icub-firmware-shared\embot\tools;..\..\..\..\libs\lowlevel\cmsis\dsp\v160\Include;..\..\..\..\libs\highlevel\abslayer\hal2\api;..\src\motorhal;..\src\model-based-design\sharedutils;..\src\model-based-design\can-decoder;..\src\model-based-design\can-raw2struct;..\src\model-based-design\supervisor-rx;..\src\model-based-design\supervisor-tx;..\src\model-based-design\can-encoder;..\src\model-based-design\control-outer;..\src\model-based-design\control-foc;..\src\model-based-design\estimator;..\src\model-based-design\amc-bldc;..\src\model-based-design\filter-current;..\..\..\..\embot\app\bldc;..\src\app-board-amcbldc;..\src\model-based-design\thermal-model
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\amcbldc-application.sct
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 5.6.0
