# Keil uVision project amcbldc-application07.uvprojx, settings and files
target amcbldc-app07-osal-ulpro (6180000::V6.18::ARMCLANG)
  device: STM32G474QETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: amcbldc +hex
  AfterMake: cmd.exe /C copy .\Obj\amcbldc.hex ..\bin\amcbldc.hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_AMCBLDC STM32HAL_DRIVER_V120
  c misc: -Wno-pragma-pack -Wno-deprecated-register -DEMBOT_USE_rtos_osal -DEMBOT_AMCBLDC_APP05
  c include: ..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\eBcode\arch-arm\libs\midware\eventviewer\api;..\..\..\..\..\..\eBcode\arch-arm\libs\lowlevel\stm32hal\api;..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\..\eBcode\arch-arm\embot\app;..\..\..\..\..\..\eBcode\arch-arm\embot\i2h;..\..\..\..\..\..\eBcode\arch-arm\embot\hw;..\..\..\..\..\..\eBcode\arch-arm\embot\os;..\..\..\..\..\..\eBcode\arch-arm\embot;..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\embot\app\dsp;..\..\..\..\..\..\..\..\icub-firmware-shared\can\canProtocolLib;..\..\..\..\embot\app\skeleton;..\..\..\..\embot\prot\can;..\..\bsp;..\src\FOCode\BLDC_FOC_Code\Current_FOC_ert_rtw;..\..\..\..\libs\lowlevel\cmsis\dsp\v160\Include;..\src\motorhal;..\src\control-foc\_sharedutils;..\..\..\..\..\..\eBcode\arch-arm\board\amcbldc\application02\src\control-foc\_sharedutils;..\src\model-based-design\sharedutils;..\src\model-based-design\can-decoder;..\src\model-based-design\can-raw2struct;..\src\model-based-design\supervisor-rx;..\src\model-based-design\supervisor-tx;..\src\model-based-design\can-encoder;..\src\model-based-design\control-outer;..\src\model-based-design\control-foc;..\src\model-based-design\estimator;..\src\model-based-design\amc-bldc;..\src\model-based-design\filter-current;..\..\..\..\libs\highlevel\abslayer\hal2\api;..\..\..\..\..\..\..\..\icub-firmware-shared\embot\tools
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\amcbldc-application.sct
  link misc: --diag_suppress=L6329
  group main
    ../src/: amcbldc-main.cpp
  group stm32hal
    ../../../../libs/lowlevel/stm32hal/lib/: stm32hal.g4.amcbldc.v120.lib
    ../cfg/: stm32hal.startup.amcbldc.s
  group rtos
    ../../../../../../eBcode/arch-arm/libs/highlevel/abslayer/osal/lib/: osal.cm4.dbg.lib
    ../../../../../../eBcode/arch-arm/libs/midware/eventviewer/src/: eventviewer.c
    ../../../../libs/highlevel/abslayer/cmsisos2/lib/: cmsisos2.lib
  group embot::core
    ../../../../../../../../icub-firmware-shared/embot/core/: embot_core.cpp embot_core_binary.cpp
  group embot::tools
    ../../../../../../../../icub-firmware-shared/embot/tools/: embot_tools.cpp
  group embot::hw
    ../../../../../../eBcode/arch-arm/embot/hw/: embot_hw.cpp embot_hw_bsp.cpp embot_hw_sys.cpp embot_hw_FlashStorage.cpp embot_hw_FlashBurner.cpp embot_hw_can.cpp embot_hw_flash.cpp embot_hw_timer.cpp embot_hw_gpio.cpp embot_hw_led.cpp embot_hw_button.cpp
    ../../../../embot/hw/: embot_hw_i2c.cpp embot_hw_tlv493d.cpp embot_hw_types.cpp embot_hw_motor.cpp
  group embot::hw::lowlevel
    ../../../../embot/hw/: embot_hw_lowlevel.cpp
  group embot::hw::bsp
    ../../bsp/: embot_hw_bsp_amcbldc.cpp
  group embot::os
    ../../../../../../eBcode/arch-arm/embot/os/: embot_os.cpp embot_os_Thread.cpp embot_os_theCallbackManager.cpp embot_os_theScheduler.cpp embot_os_theTimerManager.cpp embot_os_Timer.cpp
    ../../../../../../eBcode/arch-arm/embot/app/: embot_app_theJumper.cpp
    ../../../../embot/os/: embot_os_Action.cpp embot_os_rtos.cpp
  group embot::prot::can
    ../../../../../../eBcode/arch-arm/embot/app/: embot_app_application_theCANparserBasic.cpp
    ../../../../../../eBcode/arch-arm/embot/prot/can/: embot_prot_can.cpp embot_prot_can_skin_periodic.cpp embot_prot_can_inertial_periodic.cpp embot_prot_can_motor_polling.cpp embot_prot_can_motor_periodic.cpp embot_prot_can_bootloader.cpp embot_prot_can_analog_polling.cpp embot_prot_can_analog_periodic.cpp
  group embot::app-required
    ../../../../embot/app/skeleton/: embot_app_skeleton_os_evthreadcan.cpp embot_app_skeleton_os_basic.cpp
    ../../../../../../eBcode/arch-arm/embot/app/: embot_app_theApplication.cpp embot_app_theCANboardInfo.cpp embot_app_application_theCANtracer.cpp
    ../../../../embot/app/: embot_app_theStorage.cpp
  group embot::app-others
    ../../../../embot/app/: embot_app_scope.cpp embot_app_theLEDmanager.cpp
  group others
    ../src/: embot_app_application_theCANparserMBD.cpp embot_app_application_theMBDagent.cpp
  group others::foc
    ../../../../libs/lowlevel/cmsis/dsp/v160/Lib/ARM/: arm_cortexM4lf_math.lib
  group others::motorhal
    ../src/motorhal/: motorhal_config.c encoder.c pwm.c analog.c
  group mbd
    ../src/model-based-design/sharedutils/: rt_hypotf_snf.cpp rt_nonfinite.cpp rtGetInf.cpp rtGetNaN.cpp rtwtypes.h rtw_mutex.h rtw_enable_disable_motors.c const_params.cpp mw_cmsis.h zero_crossing_types.h uMultiWord2Double.cpp uMultiWordShl.cpp rt_roundd_snf.cpp rtw_motor_config.c
  group mbd::can-encoder
    ../src/model-based-design/can-encoder/: can_encoder.cpp can_encoder.h can_encoder_private.h can_encoder_types.h
  group mbd::can-decoder
    ../src/model-based-design/can-decoder/: can_decoder.cpp can_decoder.h can_decoder_private.h can_decoder_types.h
  group mbd::supervisor-rx
    ../src/model-based-design/supervisor-rx/: SupervisorFSM_RX.cpp SupervisorFSM_RX.h SupervisorFSM_RX_private.h SupervisorFSM_RX_types.h
  group mbd::supervisor-tx
    ../src/model-based-design/supervisor-tx/: SupervisorFSM_TX.cpp SupervisorFSM_TX.h SupervisorFSM_TX_private.h SupervisorFSM_TX_types.h
  group mbd::control-outer
    ../src/model-based-design/control-outer/: control_outer.cpp control_outer.h control_outer_private.h control_outer_types.h
  group mbd::control-foc
    ../src/model-based-design/control-foc/: control_foc.cpp FOCInnerLoop.cpp control_foc_data.cpp
  group mdb::estimator
    ../src/model-based-design/estimator/: estimation_velocity.cpp estimation_velocity.h estimation_velocity_private.h estimation_velocity_types.h
  group mbd::filter-current
    ../src/model-based-design/filter-current/: filter_current.cpp filter_current.h filter_current_private.h filter_current_types.h
  group mbd::amc-bldc
    ../src/model-based-design/amc-bldc/: AMC_BLDC.cpp AMC_BLDC.h AMC_BLDC_private.h AMC_BLDC_types.h
target amcbldc-app01-osal-stlink (6160000::V6.16::ARMCLANG)
  device: STM32G474QETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.4.0
  cpu: as above
  output: amcbldc +hex
  AfterMake: cmd.exe /C copy .\Obj\amcbldc.hex ..\bin\amcbldc.hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_AMCBLDC STM32HAL_DRIVER_V120
  c misc: -Wno-pragma-pack -Wno-deprecated-register -DEMBOT_USE_rtos_osal
  c include: ..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\eBcode\arch-arm\libs\midware\eventviewer\api;..\..\..\..\..\..\eBcode\arch-arm\libs\lowlevel\stm32hal\api;..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\..\eBcode\arch-arm\embot\app;..\..\..\..\..\..\eBcode\arch-arm\embot\i2h;..\..\..\..\..\..\eBcode\arch-arm\embot\hw;..\..\..\..\..\..\eBcode\arch-arm\embot\os;..\..\..\..\..\..\eBcode\arch-arm\embot;..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\embot\app\dsp;..\..\..\..\..\..\..\..\icub-firmware-shared\can\canProtocolLib;..\..\..\..\embot\app\skeleton;..\..\..\..\embot\prot\can;..\..\bsp
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\amcbldc-application.sct
  link misc: --diag_suppress=L6329
target amcbldc-app01-cmsisos2-ulpro (6160000::V6.16::ARMCLANG)
  device: STM32G474QETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.4.0
  cpu: as above
  output: amcbldc +hex
  AfterMake: cmd.exe /C copy .\objcmsisos2\pmc.hex ..\bin\pmc.hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=8 v6Lto=1 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_AMCBLDC STM32HAL_DRIVER_V120
  c misc: -Wno-pragma-pack -Wno-deprecated-register -DEMBOT_USE_rtos_cmsisos2
  c include: ..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\cmsisos2\api;..\..\..\..\..\..\eBcode\arch-arm\libs\lowlevel\stm32hal\api;..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\..\eBcode\arch-arm\embot\app;..\..\..\..\..\..\eBcode\arch-arm\embot\i2h;..\..\..\..\..\..\eBcode\arch-arm\embot\hw;..\..\..\..\..\..\eBcode\arch-arm\embot\os;..\..\..\..\..\..\eBcode\arch-arm\embot;..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\embot\app\dsp;..\..\..\..\..\..\..\..\icub-firmware-shared\can\canProtocolLib;..\..\..\..\embot\app\skeleton;..\..\..\..\embot\prot\can;..\..\bsp;..\..\..\..\libs\midware\eventviewer\api
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\amcbldc-application.sct
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 5.4.0
