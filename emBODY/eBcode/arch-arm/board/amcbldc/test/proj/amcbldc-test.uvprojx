# Keil uVision project amcbldc-test.uvprojx, settings and files
target amcbldc-btl (6190000::V6.19::ARMCLANG)
  device: STM32G474CCUx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: amcbldc_bootloader +hex
  AfterMake: cmd.exe /C copy .\Obj\amcbldc_bootloader.hex ..\bin\amcbldc.bootloader.hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=8 v6Lto=1 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_AMCBLDC STM32HAL_DRIVER_V120
  c misc: -Wno-pragma-pack -Wno-deprecated-register
  c include: ..\src-plus;..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\eBcode\arch-arm\libs\midware\eventviewer\api;..\..\..\..\..\..\eBcode\arch-arm\embobj\core\exec\multitask;..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core;..\..\..\..\..\..\eBcode\arch-arm\libs\lowlevel\stm32hal\api;..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\..\eBcode\arch-arm\embot\app;..\..\..\..\..\..\eBcode\arch-arm\embot\i2h;..\..\..\..\..\..\eBcode\arch-arm\embot\hw;..\..\..\..\..\..\eBcode\arch-arm\embot\os;..\..\..\..\..\..\..\..\icub-firmware-shared\can\canProtocolLib;..\..\..\..\embot\app\skeleton;..\..\..\..\embot\prot\can;..\..\bsp
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\amcbldc-bootloader.sct
  link misc: --diag_suppress=L6329
  group main
    ../src/: embot_app_skeleton_os_test.cpp main-test.cpp
  group stm32hal
    ../../../../libs/lowlevel/stm32hal/lib/: stm32hal.g4.v122.amcbldc.lib
  group stm32hal-config
    ../cfg/: stm32hal.startup.amcbldc.s
  group rtos
    ../../../../../../eBcode/arch-arm/libs/highlevel/abslayer/osal/lib/: osal.cm4.dbg.lib
    ../../../../libs/midware/eventviewer/src/: eventviewer.c
  group embot
    ../../../../../../../../icub-firmware-shared/embot/core/: embot_core.cpp embot_core_binary.cpp
    ../../../../../../eBcode/arch-arm/embot/app/: embot_app_theBootloader.cpp embot_app_theCANboardInfo.cpp embot_app_theJumper.cpp embot_app_bootloader_theCANparser.cpp
    ../../../../../../eBcode/arch-arm/embot/os/: embot_os.cpp embot_os_Thread.cpp embot_os_theCallbackManager.cpp embot_os_theScheduler.cpp embot_os_theTimerManager.cpp embot_os_Timer.cpp
    ../../../../../../eBcode/arch-arm/embot/prot/can/: embot_prot_can.cpp embot_prot_can_bootloader.cpp
    ../../../../embot/os/: embot_os_Action.cpp embot_os_rtos.cpp
    ../../../../embot/app/: embot_app_theLEDmanager.cpp
  group embot::hw
    ../../../../../../eBcode/arch-arm/embot/hw/: embot_hw.cpp embot_hw_bsp.cpp embot_hw_FlashStorage.cpp embot_hw_FlashBurner.cpp embot_hw_can.cpp embot_hw_sys.cpp embot_hw_flash.cpp embot_hw_led.cpp
    ../../../../embot/hw/: embot_hw_gpio.cpp embot_hw_timer.cpp embot_hw_types.cpp embot_hw_button.cpp embot_hw_motor.cpp embot_hw_i2c.cpp embot_hw_encoder.cpp
  group embot-hw-lowlevel
    ../../../../embot/hw/: embot_hw_lowlevel.cpp
  group embot::hw::bsp
    ../bsp/: embot_hw_bsp_amcbldc.cpp
  group motorhal2
    ../src/motorhal2/: analog.c encoder.c motorhal_config.c motorhal_faults.c pwm.c
  group tests
    ../src/: tests.cpp
target amcbldc-btl-v122 (6190000::V6.19::ARMCLANG)
  device: STM32G474CCUx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.5.0
  cpu: as above
  output: amcbldc_bootloader +hex
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=8 v6Lto=1 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_AMCBLDC STM32HAL_DRIVER_V122
  c misc: -Wno-pragma-pack -Wno-deprecated-register
  c include: ..\src-plus;..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\eBcode\arch-arm\libs\midware\eventviewer\api;..\..\..\..\..\..\eBcode\arch-arm\embobj\core\exec\multitask;..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core;..\..\..\..\..\..\eBcode\arch-arm\libs\lowlevel\stm32hal\api;..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\..\eBcode\arch-arm\embot\app;..\..\..\..\..\..\eBcode\arch-arm\embot\i2h;..\..\..\..\..\..\eBcode\arch-arm\embot\hw;..\..\..\..\..\..\eBcode\arch-arm\embot\os;..\..\..\..\..\..\..\..\icub-firmware-shared\can\canProtocolLib;..\..\..\..\embot\app\skeleton;..\..\..\..\embot\prot\can;..\..\bsp;..\src\motorhal2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\amcbldc-test.sct
  link misc: --diag_suppress=L6329
target amc-bldc-test-v122 (6190000::V6.19::ARMCLANG)
  device: STM32G474CCUx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.5.0
  cpu: as above
  output: amcbldc_test +hex
  AfterMake: cmd.exe /C copy .\Obj\amcbldc_test.hex ..\bin\amcbldc.test.hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=8 v6Lto=1 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_AMCBLDC STM32HAL_DRIVER_V122
  c misc: -Wno-pragma-pack -Wno-deprecated-register
  c include: ..\src-plus;..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\eBcode\arch-arm\libs\midware\eventviewer\api;..\..\..\..\..\..\eBcode\arch-arm\embobj\core\exec\multitask;..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core;..\..\..\..\..\..\eBcode\arch-arm\libs\lowlevel\stm32hal\api;..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\..\eBcode\arch-arm\embot\app;..\..\..\..\..\..\eBcode\arch-arm\embot\i2h;..\..\..\..\..\..\eBcode\arch-arm\embot\hw;..\..\..\..\..\..\eBcode\arch-arm\embot\os;..\..\..\..\..\..\..\..\icub-firmware-shared\can\canProtocolLib;..\..\..\..\embot\app\skeleton;..\..\..\..\embot\prot\can;..\src\motorhal2;..\bsp
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\amcbldc-test.sct
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 5.4.0
