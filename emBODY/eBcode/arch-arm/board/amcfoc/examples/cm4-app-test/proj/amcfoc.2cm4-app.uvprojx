# Keil uVision project amcfoc.2cm4-app.uvprojx, settings and files
target amc-icc-osal-ulpro (6220000::V6.22::ARMCLANG)
  device: STM32H745IIKx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x10000000,0x00048000) IROM(0x08100000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: amcfocapp +hex
  AfterMake: cmd.exe /C copy .\obj\amcfocapp.hex ..\bin\amcfoc.2cm4.app.test.hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: USE_ICC_COMM USE_EMBOT_HW EMBOBJ_USE_EMBOT USE_STM32HAL STM32HAL_BOARD_AMCFOC_2CM4 STM32HAL_DRIVER_V1A0 STM32HAL_dualcore_BOOT_cm4master
  c misc: -DxdebugNOicc -DxYRI_uses_MC_foc_actuator_descriptor_generic -DxuseMCfoc_actuator_descriptor_generic -Wno-pragma-pack -Wno-deprecated-register -DEMBOT_USE_rtos_osal -DIPAL_use_cfg2 -DUSE_EMBOT_theHandler -DUSE_EMBOT_theServices -DUSE_EMBOT_theServicesMC -DEMBOT_USE_rtos_osal
  c include: ..\..\..\..\..\libs\lowlevel\stm32hal\api;..\..\..\..\..\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\embot\hw;..\..\..\..\..\embot\os;..\..\..\..\..\embot\app;..\..\..\..\..\libs\midware\eventviewer\api;..\..\..\..\..\libs\highlevel\abslayer\ipal\api;--..\..\..\..\..\libs\highlevel\abslayer\hal2\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core;..\..\..\..\..\embobj\core\exec\multitask;..\..\..\..\..\embobj\plus\ipnet;..\src\emb-env;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\prot\eth;..\..\bsp;..\cfg;..\..\bsp\ipaldrv;..\..\..\..\..\libs\highlevel\services\embenv\api;..\..\..\..\..\embobj\plus\embenv;..\..\..\..\..\libs\highlevel\abslayer\hal2\api;..\..\..\..\..\embobj\plus\ctrloop;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\icub;..\..\..\..\..\..\..\..\..\icub-firmware-shared\can\canProtocolLib;..\..\..\..\..\embot\app\eth;.;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\transport;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\protocol\api;..\cfg\protocol\rop;..\..\..\..\..\embobj\plus\can;..\..\..\..\ems004\appl\v2\src\eoappservices;..\..\..\..\..\embobj\plus\board;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\tools;..\..\..\..\..\mbd\kalman_filter;..\..\..\..\..\embobj\plus\mc;..\..\..\..\..\libs\midware\hl-plus\api;..\..\..\..\..\embot\prot\can;..\..\..\..\..\mbd\wrist_decoupler;..\..\..\bsp\cm4;..\..\..\bsp\cm4\ipaldrv;..\..\..\bsp\shared
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x48000
  scatter file: ..\cfg\amcfoc.2cm4-application.sct
  link misc: --diag_suppress=L6329
  group main
    ../src/: amcfoc-appl-test.cpp
  group embot::app::eth
    ../../../../../embot/app/: embot_app_theLEDmanager.cpp
    ../../../../../embot/app/eth/: embot_app_eth_theIPnet.cpp embot_app_eth_theEnvironment.cpp embot_app_eth_theErrorManager.cpp embot_app_eth_theUpdaterParser.cpp embot_app_eth_theApplication.cpp embot_app_eth_theListener.cpp embot_app_eth_theBackdoor.cpp embot_app_eth_theETHmonitor.cpp
  group embot::app::eth::config
    ../cfg/: theApplication_config.h theApplication_config.cpp
  group stm32hal
    ../cfg/: stm32hal.h7.startup.amcfoc.CM4.s
    ../../../../../libs/lowlevel/stm32hal/lib/: stm32hal.h7.amcfoc.2cm4.v1A0.lib
    ../../../../../libs/lowlevel/stm32hal/src/driver/stm32h7-v1A0/extra/: system_stm32h7xx-cm4-cm7-gated.c
  group rtos
    ../../../../../libs/highlevel/abslayer/osal/lib/: osal.cm4.dbg.lib
    ../../../../../libs/midware/eventviewer/src/: eventviewer.c
  group ipal
    ../../../../../libs/highlevel/abslayer/ipal/lib/: ipal.lwip.h7.cm4.lib
    ../cfg/: ipal_cfg2.cpp
  group embot::core
    ../../../../../../../../../icub-firmware-shared/embot/core/: embot_core.cpp embot_core_binary.cpp embot_core_utils.cpp
  group embot::hw
    ../../../../../embot/hw/: embot_hw_bsp.cpp embot_hw.cpp embot_hw_gpio.cpp embot_hw_led.cpp embot_hw_sys.cpp embot_hw_flash.cpp embot_hw_spi.cpp embot_hw_eth.cpp embot_hw_eeprom.cpp embot_hw_encoder.cpp embot_hw_timer.cpp embot_hw_chip_M95512DF.cpp embot_hw_chip_AS5045.cpp embot_hw_chip_MA730.cpp embot_hw_chip_MB049.cpp embot_hw_mtx.cpp embot_hw_icc_sig.cpp embot_hw_icc_mem.cpp embot_hw_icc_ltr.cpp embot_hw_icc_printer.cpp embot_hw_chip_KSZ8563.cpp embot_hw_dualcore.cpp embot_hw_can.cpp
  group embot::hw::lowlevel
    ../../../../../embot/hw/: embot_hw_lowlevel.cpp
  group embot::hw::bsp
    ../../../bsp/cm4/ipaldrv/: PHY_KSZ8563.c ipal_hal_eth_stm32h7.c EMAC_STM32H7xx_KSZ8563.c ethram.c
  group embot::hw::bsp-core-shared
    ../../../bsp/shared/: embot_hw_bsp_DRIVER_amcfoc.cpp embot_hw_dualcore_bsp_amcfoc.cpp embot_hw_flash_bsp_amcfoc.cpp embot_hw_gpio_bsp_amcfoc.cpp embot_hw_icc_bsp_amcfoc.cpp embot_hw_mtx_bsp_amcfoc.cpp
  group embot::hw::bsp-core-cm4
    ../../../bsp/cm4/: embot_hw_bsp_amcfoc_2cm4.cpp embot_hw_can_bsp_amcfoc_2cm4.cpp embot_hw_eeprom_bsp_amcfoc_2cm4.cpp embot_hw_encoder_bsp_amcfoc_2cm4.cpp embot_hw_eth_bsp_amcfoc_2cm4.cpp embot_hw_led_bsp_amcfoc_2cm4.cpp embot_hw_spi_bsp_amcfoc_2cm4.cpp embot_hw_timer_bsp_amcfoc_2cm4.cpp
  group HAL over embot::hw
    ../../../../../embot/hw/: hal_embot.cpp
  group embot::os
    ../../../../../embot/os/: embot_os.cpp embot_os_Action.cpp embot_os_theCallbackManager.cpp embot_os_theScheduler.cpp embot_os_theTimerManager.cpp embot_os_Thread.cpp embot_os_Timer.cpp embot_os_rtos.cpp
  group embot::os::EOM
    ../../../../../embot/os/: embot_os_eom.cpp
    ../../../../../embot/os/eom/: EOMmutex.embot.cpp EOMtask.embot.cpp
  group eo-core
    ../../../../../../../../../icub-firmware-shared/eth/embobj/core/core/: EOaction.c EOarray.c EoCommon.c EOconstarray.c EOconstvector.c EOdeque.c EOfifo.c EOlist.c EOpacket.c EOsm.c EOtheErrorManager.c EOtheMemoryPool.c EOtimer.c EOvector.c EOVmutex.c EOVtask.c EOVtheCallbackManager.c EOVtheSystem.c EOVtheTimerManager.c
  group eo-theIPnet
    ../../../../../embobj/plus/ipnet/: EOMtheIPnet.c EOsocket.c EOsocketDatagram.c EOVtheIPnet.c
  group eo-theEnvironment
    ../../../../../embobj/plus/embenv/: EOtheARMenvironment.c EOVtheEnvironment.c
    ../../../../../libs/highlevel/services/embenv/src/: eEsharedServices.c eEcommon.c shalBASE.c shalINFO.c shalPART.c
  group eo-updaterprotocol
    ../../../../../../../../../icub-firmware-shared/eth/embobj/plus/comm-v2/icub/: EoUpdaterProtocol.c
  group eo-ctrl-socket
    ../../../../../embobj/plus/ctrloop/: EOMtheEMSsocket.c EOMtheEMStransceiver.c
  group eo-transport
    ../../../../../../../../../icub-firmware-shared/eth/embobj/plus/comm-v2/transport/: EOtransceiver.c EOtheBOARDtransceiver.c EOtheInfoDispatcher.c EOtheParser.c EOtransmitter.c EOagent.c EOconfirmationManager.c EOnv.c EOnvSet.c EOproxy.c EOrop.c EOreceiver.c EOropframe.c EOtheFormer.c
  group eo-rop-protocol
    ../../../../../../../../../icub-firmware-shared/eth/embobj/plus/comm-v2/protocol/src/: EoProtocol.c EoProtocolAS_fun.c EoProtocolAS_rom.c EoProtocolEPs.c EoProtocolMC_fun.c EoProtocolMC_rom.c EoProtocolMN_fun.c EoProtocolMN_rom.c EoProtocolSK_fun.c EoProtocolSK_rom.c
  group eo-rop-protocol-callbacks
    ../cfg/protocol/rop/: EoProtocolMN_fun_amc.c EoProtocolMC_fun_amc.c EoProtocolAS_fun_amc.c
  group eo-state-idle [aka cfg]
    ../../../../../embobj/plus/ctrloop/: EOMtheEMSconfigurator.c
  group eo-state-fatalerror
    ../../../../../embobj/plus/ctrloop/: EOMtheEMSerror.c
  group eo-state-run
    ../../../../../embobj/plus/ctrloop/: EOMtheEMSrunner.c
  group eo-can-mapping+protocol+service
    ../../../../../embobj/plus/can/: EOtheCANmapping.c EOtheCANprotocol.c EOtheCANservice.c
  group eo-can-protocol-callbacks
    ../cfg/protocol/can/: EoCANprotASperiodic_amc.c EoCANprotASpolling_amc.c EoCANprotISperiodic_amc.c EoCANprotMCperiodic_amc.c EoCANprotMCpolling_amc.c EoCANprotSKperiodic_amc.c EoCANprotBSperiodic_amc.c
  group eo-services
    ../../../../../embobj/plus/board/: EOtheEntities.c
    ../../../../ems004/appl/v2/src/eoappservices/: EOtheCANdiscovery2.c
  group eo-appl-state-machine
    ../../../../../embobj/plus/ctrloop/: eOcfg_sm_EMSappl.c
  group eo-icub-fw-sha/icub
    ../../../../../../../../../icub-firmware-shared/eth/embobj/plus/comm-v2/icub/: EoManagement.c EoMotionControl.c EoAnalogSensors.c EoError.c EoBoards.c
  group embot::app::eth::theServices
    ../../../../../embot/app/eth/: embot_app_eth_Service.cpp embot_app_eth_theServices.cpp
    ../../../../ems004/appl/v2/src/eoappservices/: embot_app_eth_CANmonitor.cpp
  group embot::app::eth::theHandler
    ../../../../../embot/app/eth/: embot_app_eth_theHandler.cpp
    ../cfg/: theHandler_config.h
  group embot::app::scope
    ../../../../../../../../../icub-firmware-shared/embot/tools/: embot_tools.cpp
    ../../../../../embot/app/: embot_app_scope.cpp
  group embot::app::eth::theServiceMC
    ../../../../../embot/app/eth/: embot_app_eth_theServiceMC2.cpp embot_app_eth_Service_impl_mc_SERVICE.cpp embot_app_eth_Service_impl_mc_AGENTs.cpp embot_app_eth_Service_impl_mc_AGENTfoc.cpp embot_app_eth_Service_impl_mc_AGENTadvfoc.cpp embot_app_msg.cpp embot_app_eth_mc_messaging.cpp
    ../../../../../embot/prot/can/: embot_prot_can.cpp
  group eo-motor-controller
    ../../../../../embobj/plus/mc/: AbsEncoder.c Calibrators.c Controller.c Joint.c JointSet.c Motor.c Pid.c Trajectory.c WatchDog.c
  group mbd::kalman-filter
    ../../../../../mbd/kalman_filter/: kalman_filter.cpp kalman_filter_data.cpp
  group mbd::wrist-decoupler
    ../../../../../mbd/wrist_decoupler/: wrist_decoupler.cpp
  group embot::app::eth::theEncoderReader
    ../../../../../embot/app/eth/: embot_app_eth_theEncoderReader.cpp
  group embot::app::eth::theServiceFT
    ../../../../../embot/app/eth/: embot_app_eth_theServiceFT.cpp
    ../../../../ems004/appl/v2/src/eoappservices/: embot_app_eth_theFTservice.cpp
  group embot::app::eth::theICCservice
    ../../../../../embot/app/eth/: embot_app_eth_theICCservice.cpp embot_app_eth_theICCmapping.cpp
  group embot::app::tester
    ../../../../ems004/appl/v2/src/eoappservices/: servicetester.cpp embot_app_eth_theServiceTester.cpp embot_app_eth_theMCserviceEOtesterconfig.cpp
