# Keil uVision project amcfoc.2cm4.mot.uvprojx, settings and files
target amcfoc.2cm4-slave (6230000::V6.23::ARMCLANG)
  device: STM32H745IIKx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.2
  cpu: IRAM(0x10000000,0x00048000) IROM(0x08100000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: cm4slave +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: EMBOT_ENABLE_hw_minimal STM32HAL_dualcore_BOOT_cm7master USE_STM32HAL STM32HAL_BOARD_AMCFOC_2CM4 STM32HAL_DRIVER_V1B5
  c misc: -Wno-pragma-pack -Wno-deprecated-register -DEMBOT_USE_rtos_osal
  c include: ..\..\..\..\..\libs\lowlevel\stm32hal\api;..\..\..\..\..\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\embot\hw;..\..\..\..\..\embot\os;..\..\..\..\..\embot\app;..\..\..\..\..\libs\midware\eventviewer\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\tools;..\..\..\bsp\cm4;..\..\..\bsp\shared
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x48000
  scatter file: ..\cfg\amcfoc.2cm4-template.sct
  link misc: --diag_suppress=L6329
  group main
    ../src/: main-motor.cpp
  group stm32hal
    ../cfg/: stm32hal.h7.startup.amcfoc.CM4.s
    ../../../../../libs/lowlevel/stm32hal/lib/: stm32hal.h7.amcfoc.2cm4.v1B5.lib
    ../../../../../libs/lowlevel/stm32hal/src/driver/stm32h7-v1B5/extra/: system_stm32h7xx-cm4-cm7-gated.c
  group rtos
    ../../../../../libs/highlevel/abslayer/osal/lib/: osal.cm4.dbg.lib
    ../../../../../libs/midware/eventviewer/src/: eventviewer.c
  group embot::core
    ../../../../../../../../../icub-firmware-shared/embot/core/: embot_core.cpp embot_core_binary.cpp embot_core_utils.cpp
  group embot::os
    ../../../../../embot/os/: embot_os.cpp embot_os_Action.cpp embot_os_theCallbackManager.cpp embot_os_theScheduler.cpp embot_os_theTimerManager.cpp embot_os_Thread.cpp embot_os_Timer.cpp embot_os_rtos.cpp
  group embot::app
    ../../../../../embot/app/: embot_app_theLEDmanager.cpp embot_app_scope.cpp
    ../../../../../../../../../icub-firmware-shared/embot/tools/: embot_tools.cpp
  group embot::hw-core
    ../../../../../embot/hw/: embot_hw_bsp.cpp embot_hw.cpp embot_hw_gpio.cpp embot_hw_led.cpp embot_hw_sys.cpp embot_hw_can.cpp embot_hw_flash.cpp embot_hw_dualcore.cpp
  group embot::hw::lowlevel
    ../../../../../embot/hw/: embot_hw_lowlevel.cpp
  group embot::hw::bsp-core-shared
    ../../../bsp/shared/: embot_hw_dualcore_bsp_amcfoc.cpp embot_hw_bsp_DRIVER_amcfoc.cpp embot_hw_gpio_bsp_amcfoc.cpp embot_hw_flash_bsp_amcfoc.cpp embot_hw_led_bsp_pinout_amcfoc.h embot_hw_can_bsp_amcfoc.cpp embot_hw_led_bsp_amcfoc.cpp
  group embot::hw::bsp-core-cm4
    ../../../bsp/cm4/: embot_hw_bsp_amcfoc_2cm4.cpp
  group embot::hw-mot
    ../../../../../embot/hw/: embot_hw_motor_bldc.cpp
  group embot::hw::bsp-mot
    ../../../bsp/portable/: embot_hw_motor_bldc_bsp_amcfoc.cpp
    ../../../bsp/portable/motor/: embot_hw_analog.cpp embot_hw_motor_adc.cpp embot_hw_motor_enc.cpp embot_hw_motor_hall.cpp embot_hw_motor_pwm.cpp
target amcfoc.2cm4-master (6230000::V6.23::ARMCLANG)
  device: STM32H745IIKx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.2
  cpu: as above
  output: cm4master +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: EMBOT_ENABLE_hw_MOT STM32HAL_dualcore_BOOT_cm4master USE_STM32HAL STM32HAL_BOARD_AMCFOC_2CM4 STM32HAL_DRIVER_V1B5
  c misc: as above
  c include: ..\..\..\..\..\libs\lowlevel\stm32hal\api;..\..\..\..\..\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\embot\hw;..\..\..\..\..\embot\os;..\..\..\..\..\embot\app;..\..\..\..\..\libs\midware\eventviewer\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\tools;..\..\..\bsp\cm4;..\..\..\bsp\shared;..\..\..\bsp\portable;..\..\..\bsp\portable\motor
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x48000
  scatter file: ..\cfg\amcfoc.2cm4-template.sct
  link misc: --diag_suppress=L6329
