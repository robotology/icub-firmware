# Keil uVision project amcmj1.appl.gateway.01.uvprojx, settings and files
target amcmj1.2cm4-master (6240000::V6.24::ARMCLANG)
  device: STM32H747AIIx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.0
  cpu: IRAM(0x10000000,0x00048000) IROM(0x08100000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: h7udpdemocm4 +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: STM32HAL_dualcore_BOOT_cm4master USE_STM32HAL STM32HAL_BOARD_AMCMJ1 STM32HAL_BOARD_AMCMJ1_2CM4 STM32HAL_DRIVER_V1B6 USE_EMBOT_HW
  c misc: -DEMBOT_HW_BSP__appl_gateway -Wno-pragma-pack -Wno-deprecated-register -DEMBOT_USE_rtos_cmsisrtx  -DIPAL_use_cfg2
  c include: ..\..\..\..\..\libs\lowlevel\stm32hal\api;..\..\..\..\..\libs\highlevel\abslayer\cmsisrtx\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\embot\hw;..\..\..\..\..\embot\os;..\..\..\..\..\embot\app;..\..\..\..\..\libs\midware\eventviewer\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\tools;..\..\..\bsp\cm4;..\..\..\bsp\shared;..\..\..\bsp\portable;..\cfg;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\prot\eth;..\..\cmx-lwip\src\bsp;.;..\..\..\..\..\libs\lowlevel\lwip\LwIP\src\include;..\..\..\..\..\libs\lowlevel\lwip\LwIP\system;..\..\..\..\..\libs\lowlevel\lwip\cfg;.;..\..\..\..\..\embot\app\eth;..\..\..\..\..\libs\highlevel\abslayer\elwip\api;..\..\..\..\..\embot\net;..\..\..\..\..\embot\svc
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x48000
  scatter file: ..\cfg\amcmj1.2cm4-lwip-0offset.sct
  link misc: --diag_suppress=L6329
  group main
    ../src/: appl.gateway.01.cpp dictionary.amcmj1.cpp amcmj1_paxdriver.cpp amcmj1_canbus.cpp amcmj1_cubedriver.cpp amcmj1_gwlink.cpp amcmj1_motdriver.cpp amcmj1_posdriver.cpp
  group embot::svc
    ../../../../../embot/svc/: embot_svc_theTETHERservice.cpp embot_svc_tether_SharedVariables.cpp embot_svc_tether_theRPCmanager.cpp embot_svc_tether_theSTRmanager.cpp
  group stm32hal
    ../cfg/: stm32hal.h7.startup.amcmj1.s
    ../../../../../libs/lowlevel/stm32hal/src/driver/stm32h7-v1A0/extra/: system_stm32h7xx-cm4-cm7-gated.c
    ../../../../../libs/lowlevel/stm32hal/lib/: stm32hal.h7.amcmj1.1cm7.v1B6.lib stm32hal.h7.amcmj1.2cm4.v1B6.lib
  group rtos
    ../../../../../libs/midware/eventviewer/src/: eventviewer.c
    ../../../../../libs/highlevel/abslayer/cmsisrtx/lib/: cmsisrtx.debug.cm4.lib cmsisrtx.debug.cm7.lib
  group embot::core
    ../../../../../../../../../icub-firmware-shared/embot/core/: embot_core.cpp embot_core_binary.cpp embot_core_utils.cpp
  group embot::hw-core
    ../../../../../embot/hw/: embot_hw_bsp.cpp embot_hw.cpp embot_hw_gpio.cpp embot_hw_led.cpp embot_hw_sys.cpp embot_hw_can.cpp embot_hw_flash.cpp embot_hw_dualcore.cpp
  group embot::os
    ../../../../../embot/os/: embot_os.cpp embot_os_Action.cpp embot_os_theCallbackManager.cpp embot_os_theScheduler.cpp embot_os_theTimerManager.cpp embot_os_Thread.cpp embot_os_Timer.cpp embot_os_rtos.cpp
  group embot::app
    ../../../../../embot/svc/: embot_svc_theLEDmanager.cpp
    ../../../../../embot/app/: embot_app_scope.cpp
    ../../../../../../../../../icub-firmware-shared/embot/tools/: embot_tools.cpp
  group embot::hw::bsp-core-shared
    ../../../bsp/shared/: embot_hw_dualcore_bsp_amcmj1.cpp embot_hw_bsp_DRIVER_amcmj1.cpp embot_hw_gpio_bsp_amcmj1.cpp embot_hw_flash_bsp_amcmj1.cpp embot_hw_led_bsp_pinout_amcmj1.h
    ../../../bsp/portable/: embot_hw_can_bsp_amcmj1.cpp
  group embot::hw::lowlevel
    ../../../../../embot/hw/: embot_hw_lowlevel.cpp
  group embot::hw::bsp-core-cmx
    ../../../bsp/shared/: embot_hw_led_bsp_amcmj1.cpp
    ../../../bsp/portable/: embot_hw_spi_bsp_amcmj1.cpp embot_hw_eeprom_bsp_amcmj1.cpp
    ../../../bsp/cm7/: embot_hw_bsp_amcmj1_1cm7.cpp
    ../../../bsp/cm4/: embot_hw_bsp_amcmj1_2cm4.cpp
  group embot::hw-others
    ../../../../../embot/hw/: embot_hw_eeprom.cpp embot_hw_eth.cpp embot_hw_spi.cpp embot_hw_chip_M95512DF.cpp embot_hw_chip_KSZ8563.cpp
  group embot:hw::eth::bsp
    ../../../bsp/portable/: embot_hw_eth_bsp_amcmj1.cpp
  group embot::net
    ../../../../../embot/net/: embot_net_lwip.cpp embot_net_eth_Packet.cpp embot_net_eth_Socket.cpp embot_net_eth_theIPservice.cpp
    ../../../../../embot/svc/: embot_svc_theLogger.cpp
  group embot::lwip
    ../../../../../embot/hw/: embot_hw_lwip.cpp
    ../../../../../libs/lowlevel/lwip/lib/: lwip.8udp.tx8k.cm7.lib lwip.8udp.tx8k.cm4.lib
target amcmj1.1cm7-master (6240000::V6.24::ARMCLANG)
  device: STM32H747AIIx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) XRAM(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: h7udpdemocmsisrtx +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: STM32HAL_dualcore_BOOT_cm7master USE_STM32HAL STM32HAL_BOARD_AMCMJ1 STM32HAL_BOARD_AMCMJ1_1CM7 STM32HAL_DRIVER_V1B6 USE_EMBOT_HW
  c misc: -DEMBOT_NET_LWIP_activated -DEMBOT_HW_BSP__udpdemoipnet -DEMBOBJ_USE_EMBOT -Wno-pragma-pack -Wno-deprecated-register -DEMBOT_USE_rtos_cmsisrtx -DEMBOT_OS_RTOS_CMSISRTX_FASTRAM  -DIPAL_use_cfg2
  c include: ..\..\..\..\..\libs\lowlevel\stm32hal\api;..\..\..\..\..\libs\highlevel\abslayer\cmsisrtx\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\embot\hw;..\..\..\..\..\embot\os;..\..\..\..\..\embot\app;..\..\..\..\..\libs\midware\eventviewer\api;..\..\..\..\..\libs\highlevel\services\embenv\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\tools;..\..\..\bsp\cm7;..\..\..\bsp\shared;..\..\..\bsp\portable;..\..\..\..\..\libs\highlevel\abslayer\ipal\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core;..\..\..\..\..\embobj\core\exec\multitask;..\..\..\..\..\embobj\plus\ipnet;..\cfg;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\prot\eth;..\..\cmx-lwip\src\bsp;.;..\..\..\..\..\libs\lowlevel\lwip\LwIP\src\include;..\..\..\..\..\libs\lowlevel\lwip\LwIP\system;..\..\..\..\..\libs\lowlevel\lwip\cfg;.;..\..\..\..\..\embot\app\eth;..\..\cmx-lwip\src\lwip;..\..\..\..\..\libs\highlevel\abslayer\elwip\api;..\..\..\..\..\embot\net;..\..\..\..\..\embot\svc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: ..\cfg\amcmj1.1cm7-lwip-0offset.fastram.sct
  link misc: --diag_suppress=L6329
