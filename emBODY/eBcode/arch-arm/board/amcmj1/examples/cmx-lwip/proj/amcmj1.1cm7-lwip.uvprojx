# Keil uVision project amcmj1.1cm7-lwip.uvprojx, settings and files
target amcmj1.1cm7-lwip (6240000::V6.24::ARMCLANG)
  device: STM32H747AIIx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) XRAM(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: cm7master +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: STM32HAL_dualcore_BOOT_cm7master USE_STM32HAL STM32HAL_BOARD_AMCMJ1_1CM7 STM32HAL_DRIVER_V1B6
  c misc: -DEMBOT_NET_LWIP_activated -Wno-pragma-pack -Wno-deprecated-register -DEMBOT_USE_rtos_osal
  c include: ..\..\..\..\..\libs\lowlevel\stm32hal\api;..\..\..\..\..\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\embot\hw;..\..\..\..\..\embot\os;..\..\..\..\..\embot\app;..\..\..\..\..\libs\midware\eventviewer\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\tools;..\..\..\bsp\shared;..\..\..\bsp\cm7;..\..\..\bsp\portable;..\..\..\..\common\env\dualcore\info;..\cfg;.;..\src\lwip-code;..\..\..\..\..\libs\highlevel\abslayer\ipal\api;.;..\src\bsp;..\..\..\..\..\embot\app\eth;..\..\..\..\..\libs\lowlevel\lwip\LwIP\src\include;..\..\..\..\..\libs\lowlevel\lwip\LwIP\system;..\..\..\..\..\libs\lowlevel\lwip\cfg;..\..\..\..\..\embot\net
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: ..\cfg\amcmj1.1cm7-lwip-0offset.sct
  link misc: --diag_suppress=L6329
  group main
    ../src/: main-lwip-udpserver.cpp
  group stm32hal
    ../cfg/: stm32hal.h7.startup.amcmj1.s
    ../../../../../libs/lowlevel/stm32hal/lib/: stm32hal.h7.amcmj1.1cm7.v1B6.lib stm32hal.h7.amcmj1.2cm4.v1B6.lib
    ../../../../../libs/lowlevel/stm32hal/src/driver/stm32h7-v1A0/extra/: system_stm32h7xx-cm4-cm7-gated.c
  group rtos
    ../../../../../libs/highlevel/abslayer/osal/lib/: osal.cm4.dbg.lib
    ../../../../../libs/midware/eventviewer/src/: eventviewer.c
  group embot::core
    ../../../../../../../../../icub-firmware-shared/embot/core/: embot_core.cpp embot_core_binary.cpp embot_core_utils.cpp
  group embot::os
    ../../../../../embot/os/: embot_os.cpp embot_os_Action.cpp embot_os_theCallbackManager.cpp embot_os_theScheduler.cpp embot_os_theTimerManager.cpp embot_os_Thread.cpp embot_os_Timer.cpp embot_os_rtos.cpp
  group embot::app
    ../../../../../embot/app/: embot_app_theLEDmanager.cpp embot_app_scope.cpp
    ../../../../../../../../../icub-firmware-shared/embot/tools/: embot_tools.cpp
  group embot::hw::lowlevel
    ../../../../../embot/hw/: embot_hw_lowlevel.cpp
  group embot::hw-minimal
    ../../../../../embot/hw/: embot_hw_bsp.cpp embot_hw.cpp embot_hw_gpio.cpp embot_hw_led.cpp embot_hw_sys.cpp embot_hw_flash.cpp embot_hw_dualcore.cpp
  group embot::hw::bsp-minimal-shared
    ../../../bsp/shared/: embot_hw_dualcore_bsp_amcmj1.cpp embot_hw_bsp_DRIVER_amcmj1.cpp embot_hw_gpio_bsp_amcmj1.cpp embot_hw_flash_bsp_amcmj1.cpp embot_hw_led_bsp_pinout_amcmj1.h embot_hw_led_bsp_amcmj1.cpp
  group embot::hw::bsp-minimal-cmx
    ../../../bsp/cm7/: embot_hw_bsp_amcmj1_1cm7.cpp
    ../../../bsp/cm4/: embot_hw_bsp_amcmj1_2cm4.cpp
  group embot::hw
    ../../../../../embot/hw/: embot_hw_can.cpp embot_hw_mtx.cpp embot_hw_icc_ltr.cpp embot_hw_icc_mem.cpp embot_hw_icc_sig.cpp embot_hw_eeprom.cpp embot_hw_spi.cpp embot_hw_chip_M95512DF.cpp
  group embot::hw::bsp-shared
    ../../../bsp/shared/: embot_hw_mtx_bsp_amcmj1.cpp embot_hw_icc_bsp_amcmj1.cpp
  group embot::hw::bsp-portable
    ../../../bsp/portable/: embot_hw_can_bsp_amcmj1.cpp embot_hw_spi_bsp_amcmj1.cpp embot_hw_eeprom_bsp_amcmj1.cpp
  group embot::net::lwip
    ../../../../../embot/net/: embot_net_lwip.cpp embot_net_eth_packet.cpp
    ../../../../../libs/lowlevel/lwip/lib/: lwip.6udp.9pkt.cm7.lib lwip.6udp.9pkt.cm4.lib
  group embot::hw::lwip
    ../../../../../embot/hw/: embot_hw_lwip.cpp embot_hw_eth.cpp embot_hw_chip_KSZ8563.cpp
    ../../../bsp/portable/: embot_hw_eth_bsp_amcmj1.cpp
target amcmj1.2cm4-lwip (6240000::V6.24::ARMCLANG)
  device: STM32H747AIIx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.0
  cpu: IRAM(0x10000000,0x00048000) IROM(0x08100000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: cm4master +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: STM32HAL_dualcore_BOOT_cm4master USE_STM32HAL STM32HAL_BOARD_AMCMJ1_2CM4 STM32HAL_DRIVER_V1B6
  c misc: as above
  c include: ..\..\..\..\..\libs\lowlevel\stm32hal\api;..\..\..\..\..\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\embot\hw;..\..\..\..\..\embot\os;..\..\..\..\..\embot\app;..\..\..\..\..\libs\midware\eventviewer\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\tools;..\..\..\bsp\shared;..\..\..\bsp\cm4;..\..\..\bsp\portable;..\..\..\..\common\env\dualcore\info;..\cfg;.;..\src\lwip-code;..\..\..\..\..\libs\highlevel\abslayer\ipal\api;.;..\src\bsp;..\..\..\..\..\embot\app\eth;..\..\..\..\..\libs\lowlevel\lwip\LwIP\src\include;..\..\..\..\..\libs\lowlevel\lwip\LwIP\system;..\..\..\..\..\libs\lowlevel\lwip\cfg;..\..\..\..\..\embot\net
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x48000
  scatter file: ..\cfg\amcmj1.2cm4-lwip-0offset.sct
  link misc: --diag_suppress=L6329
