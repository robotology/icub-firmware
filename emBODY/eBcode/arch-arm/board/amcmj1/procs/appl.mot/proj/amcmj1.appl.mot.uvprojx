# Keil uVision project amcmj1.appl.mot.uvprojx, settings and files
target amcmj1.2cm4-slave (6240000::V6.24::ARMCLANG)
  device: STM32H747AIIx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x10000000,0x00048000) IROM(0x08100000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: cm4slave +hex
  AfterMake: cmd.exe /C copy .\tmp.cm4\obj\cm4slave.hex ..\bin\amcmj1.2cm4.app.mot.hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: STM32HAL_dualcore_BOOT_cm7master USE_STM32HAL STM32HAL_BOARD_AMCMJ1 STM32HAL_BOARD_AMCMJ1_2CM4 STM32HAL_DRIVER_V1B5
  c misc: -DEMBOT_HW_BSP__appl_MOT -DbldcMBDinterfaceMOCK -DtemporaryDISABLEqencMBD -D_dont_DEBUG_canQENCemission -DUSE_ICC_COMM -DUSE_ICC_CAN_COMM -Wno-pragma-pack -Wno-deprecated-register -DEMBOT_USE_rtos_osal
  c include: ..\..\..\..\..\libs\lowlevel\stm32hal\api;..\..\..\..\..\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\embot\hw;..\..\..\..\..\embot\os;..\..\..\..\..\embot\app;..\..\..\..\..\libs\midware\eventviewer\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\tools;..\..\..\bsp\cm4;..\..\..\bsp\shared;.;..\..\..\..\..\embot\prot\can;..\..\..\..\..\embot\app\eth;..\..\..\..\..\embot\app\bldc;..\src\app-board;..\..\..\..\..\libs\highlevel\services\embenv\api;..\..\..\..\common\env\dualcore\info;..\..\..\..\..\mbd\amcfoc\control-foc;..\..\..\..\..\mbd\amcfoc\control-outer;..\..\..\..\..\mbd\amcfoc\estimation-velocity;..\..\..\..\..\mbd\amcfoc\filter-current;..\..\..\..\..\mbd\amcfoc\iterative-motion-controller;..\..\..\..\..\mbd\amcfoc\motion-controller;..\..\..\..\..\mbd\amcfoc\process-sensors;..\..\..\..\..\mbd\amcfoc\sharedutils;..\..\..\..\..\mbd\amcfoc\supervisor;..\..\..\..\..\mbd\amcfoc\supervisor-tx;..\..\..\..\..\mbd\amcfoc\trajectory-planner
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x48000
  scatter file: ..\cfg\amcmj1.appl.mot-2cm4.sct
  link misc: --diag_suppress=L6329
  group main
    ../src/: main.appl.mot.cpp
  group embot::app::board
    ../src/app-board/: embot_app_board_info.cpp embot_app_board_mbd.icc.cpp
  group embot::app
    ../../../../../embot/app/: embot_app_application_theCANagentCORE2.cpp embot_app_theLEDmanager.cpp embot_app_scope.cpp embot_app_application_theCANparserCORE.cpp embot_app_application_theCANtracer.cpp embot_app_application_theCANparserMC2.cpp
    ../../../../../../../../../icub-firmware-shared/embot/tools/: embot_tools.cpp
    ../../../../../embot/app/eth/: embot_app_eth_theICCservice.cpp embot_app_eth_theICCserviceROP.cpp embot_app_eth_theICCserviceCAN.cpp
  group embot::app::bldc
    ../../../../../embot/app/bldc/: embot_app_bldc_theMBD.cpp embot_app_bldc_theMC2agent.cpp embot_app_bldc_MBD_interface.cpp embot_app_bldc_theCOMMcanicc.cpp embot_app_bldc_theApplication.cpp embot_app_bldc_theCTRL.cpp embot_app_bldc_theMSGbroker.cpp
  group embot::app::bldc::mock
    ../../../../../embot/app/bldc/: embot_app_bldc_MBD_interface_mock.cpp
  group embot::prot::can
    ../../../../../embot/prot/can/: embot_prot_can.cpp embot_prot_can_analog_periodic.cpp embot_prot_can_analog_polling.cpp embot_prot_can_bootloader.cpp embot_prot_can_inertial_periodic.cpp embot_prot_can_motor_periodic.cpp embot_prot_can_motor_polling.cpp embot_prot_can_skin_periodic.cpp
  group stm32hal
    ../../../../../libs/lowlevel/stm32hal/lib/: stm32hal.h7.amcmj1.1cm7.v1B5.lib stm32hal.h7.amcmj1.2cm4.v1B5.lib
    ../../../../../libs/lowlevel/stm32hal/src/driver/stm32h7-v1A0/extra/: system_stm32h7xx-cm4-cm7-gated.c
    ../cfg/: stm32hal.h7.startup.amcmj1.appl.mot.s
  group rtos
    ../../../../../libs/highlevel/abslayer/osal/lib/: osal.cm4.dbg.lib
    ../../../../../libs/midware/eventviewer/src/: eventviewer.c
  group embot::core
    ../../../../../../../../../icub-firmware-shared/embot/core/: embot_core.cpp embot_core_binary.cpp embot_core_utils.cpp
  group embot::os
    ../../../../../embot/os/: embot_os.cpp embot_os_Action.cpp embot_os_theCallbackManager.cpp embot_os_theScheduler.cpp embot_os_theTimerManager.cpp embot_os_Thread.cpp embot_os_Timer.cpp embot_os_rtos.cpp
  group embot::hw::lowlevel
    ../../../../../embot/hw/: embot_hw_lowlevel.cpp
  group embot::hw-core
    ../../../../../embot/hw/: embot_hw_bsp.cpp embot_hw.cpp embot_hw_gpio.cpp embot_hw_led.cpp embot_hw_sys.cpp embot_hw_flash.cpp embot_hw_dualcore.cpp
  group embot::hw::bsp-core-shared
    ../../../bsp/shared/: embot_hw_dualcore_bsp_amcmj1.cpp embot_hw_bsp_DRIVER_amcmj1.cpp embot_hw_gpio_bsp_amcmj1.cpp embot_hw_flash_bsp_amcmj1.cpp embot_hw_led_bsp_pinout_amcmj1.h embot_hw_led_bsp_amcmj1.cpp
  group embot::hw::bsp-core-cm7
    ../../../bsp/cm7/: embot_hw_bsp_amcmj1_1cm7.cpp
  group embot::hw::bsp-core-cm4
    ../../../bsp/cm4/: embot_hw_bsp_amcmj1_2cm4.cpp
  group embot::hw-others-shared
    ../../../../../embot/hw/: embot_hw_can.cpp embot_hw_mtx.cpp embot_hw_icc_ltr.cpp embot_hw_icc_mem.cpp embot_hw_icc_sig.cpp
  group embot::hw::bsp-others-shared
    ../../../bsp/shared/: embot_hw_mtx_bsp_amcmj1.cpp embot_hw_icc_bsp_amcmj1.cpp
    ../../../bsp/portable/: embot_hw_can_bsp_amcmj1.cpp
  group embot::hw::motor::bldc
    ../../../../../embot/hw/: embot_hw_motor_bldc.cpp embot_hw_motor_bldc_adc.cpp embot_hw_motor_bldc_hall.cpp embot_hw_motor_bldc_pwm.cpp embot_hw_motor_bldc_qenc.cpp embot_hw_analog.cpp embot_hw_button.cpp embot_hw_motor_bldc_extfault.cpp
  group embot::hw::motor::bldc::bsp
    ../../../bsp/portable/: embot_hw_motor_bldc_bsp_amcmj1.cpp
    ../../../bsp/portable/motor/: embot_hw_motor_bldc_qenc_bsp_amcmj1.cpp embot_hw_analog_bsp_amcmj1.cpp embot_hw_motor_bldc_pwm_bsp_amcmj1.cpp embot_hw_motor_bldc_adc_bsp_amcmj1.cpp embot_hw_motor_bldc_hall_bsp_amcmj1.cpp embot_hw_motor_bldc_extfault_bsp_amcmj1.cpp embot_hw_button_bsp_amcmj1.cpp
  group embot::hw::eeprom
    ../../../bsp/portable/: embot_hw_eeprom_bsp_amcmj1.cpp embot_hw_spi_bsp_amcmj1.cpp
    ../../../../../embot/hw/: embot_hw_eeprom.cpp embot_hw_spi.cpp embot_hw_chip_M95512DF.cpp
  group mbd::sharedutils
    ../../../../../mbd/amcmj1/sharedutils/: const_params.cpp mul_s32_sat.cpp mul_wide_s32.cpp rt_hypotf.cpp rt_roundf.cpp rt_remf.cpp
  group mbd
    ../../../../../mbd/amcmj1/sharedutils/: rtw_enable_disable_motors.cpp rtw_motor_config.cpp
    ../../../../../mbd/amcmj1/iterative-motion-controller/: iterative_motion_controller.cpp
  group mbd::supervisor
    ../../../../../mbd/amcmj1/supervisor/: supervisor.cpp
  group mbd::supervisor-tx
    ../../../../../mbd/amcmj1/supervisor-tx/: SupervisorFSM_TX.cpp
  group mbd::control-outer
    ../../../../../mbd/amcmj1/control-outer/: position_velocity_cascade.cpp
  group mbd::control-foc
    ../../../../../mbd/amcmj1/control-foc/: control_foc.cpp FOCInnerLoop.cpp
  group mbd::estimator-velocity
    ../../../../../mbd/amcmj1/estimation-velocity/: estimation_velocity.cpp
  group mbd::filter-current
    ../../../../../mbd/amcmj1/filter-current/: filter_current.cpp
  group mbd::motion-controller
    ../../../../../mbd/amcmj1/motion-controller/: motion_controller.cpp motion_controller_data.cpp
  group mbd::process-sensors
    ../../../../../mbd/amcmj1/process-sensors/: process_sensors.cpp
  group mbd::trajectory-planner
    ../../../../../mbd/amcmj1/trajectory-planner/: trajectory_planner.cpp
target amcmj1.1cm7-slave (6230000::V6.23::ARMCLANG)
  device: STM32H747AIIx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) XRAM(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: cm7slave +hex
  AfterMake: cmd.exe /C copy .\tmp.cm7\obj\cm7slave.hex ..\bin\amcmj1.1cm7.app.mot.hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: STM32HAL_dualcore_BOOT_cm4master USE_STM32HAL STM32HAL_BOARD_AMCMJ1 STM32HAL_BOARD_AMCMJ1_1CM7 STM32HAL_DRIVER_V1B5
  c misc: -DEMBOT_HW_BSP__appl_MOT -DtemporaryDISABLEqencMBD -D_dont_DEBUG_canQENCemission -DUSE_ICC_COMM -DUSE_ICC_CAN_COMM -Wno-pragma-pack -Wno-deprecated-register -DEMBOT_USE_rtos_osal
  c include: ..\..\..\..\..\libs\lowlevel\stm32hal\api;..\..\..\..\..\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\embot\hw;..\..\..\..\..\embot\os;..\..\..\..\..\embot\app;..\..\..\..\..\libs\midware\eventviewer\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\tools;..\..\..\bsp\cm7;..\..\..\bsp\shared;.;..\..\..\..\..\embot\prot\can;..\..\..\..\..\embot\app\eth;..\..\..\..\..\embot\app\bldc;..\src\app-board;..\..\..\..\..\libs\highlevel\services\embenv\api;..\..\..\..\common\env\dualcore\info;..\..\..\..\common\env\dualcore\sharedservices;.;..\..\..\..\..\mbd\amcmj1\sharedutils;..\..\..\..\..\mbd\amcmj1\control-foc;..\..\..\..\..\mbd\amcmj1\control-outer;..\..\..\..\..\mbd\amcmj1\estimation-velocity;..\..\..\..\..\mbd\amcmj1\filter-current;..\..\..\..\..\mbd\amcmj1\motion-controller;..\..\..\..\..\mbd\amcmj1\supervisor;..\..\..\..\..\mbd\amcmj1\supervisor-tx;..\..\..\..\..\mbd\amcmj1\iterative-motion-controller\;..\..\..\..\..\mbd\amcmj1\process-sensors;..\..\..\..\..\mbd\amcmj1\trajectory-planner
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: ..\cfg\amcmj1.appl.mot-1cm7.sct
  link misc: --diag_suppress=L6329
