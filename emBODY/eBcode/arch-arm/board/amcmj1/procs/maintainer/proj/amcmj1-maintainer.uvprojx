# Keil uVision project amcmj1-maintainer.uvprojx, settings and files
target amcmj1.maintainer.1cm7 (6230000::V6.23::ARMCLANG)
  device: STM32H747AIIx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) XRAM(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: amcmj1_emaintainer_cm7 +hex
  AfterMake: cmd.exe /C copy .\objcm7\amcmj1_emaintainer_cm7.hex ..\bin\amcmj1.maintainer.cm7.hex
  c flags: OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_AMCMJ1 STM32HAL_BOARD_AMCMJ1_1CM7 STM32HAL_DRIVER_V1B6 STM32HAL_dualcore_BOOT_cm7master _MAINTAINER_APPL_ USE_EMBOT_HW EMBOT_HW_BSP__maintainer
  c misc: -DEMBOT_NET_LWIP_activated -DEMBOBJ_USE_EMBOT -Ddualcore_BOOT_cm7master -Wno-pragma-pack -Wno-deprecated-register -DEMBOT_USE_rtos_osal -DIPAL_use_cfg2
  c include: ..\..\..\..\..\libs\lowlevel\stm32hal\api;..\..\..\..\..\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\embot\hw;..\..\..\..\..\embot\os;..\..\..\..\..\embot\app;..\..\..\..\..\libs\midware\eventviewer\api;..\..\..\bsp\cm7;..\..\..\bsp\shared;..\..\..\bsp\portable;..\..\..\bsp\portable\eth;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\tools;..\..\..\..\..\libs\highlevel\services\embenv\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\tools;..\..\..\bsp\cm7;..\..\..\bsp\shared;..\..\..\bsp\portable;..\..\..\bsp\portable\eth;..\..\..\..\..\libs\highlevel\abslayer\ipal\api;..\..\..\..\..\libs\highlevel\abslayer\hal2\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core;..\..\..\..\..\embobj\core\exec\multitask;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\prot\eth;..\..\..\..\..\..\..\..\..\icub-firmware-shared\can\canProtocolLib;..\..\..\..\common\env\dualcore\eUpdater;..\..\..\..\common\env\dualcore\info;..\..\..\..\..\embobj\plus\ipnet;..\cfg;..\..\..\..\..\embobj\plus\embenv;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\icub;..\..\..\..\..\libs\highlevel\services\embenv\api;..\..\..\..\..\embot\net;..\..\..\..\..\libs\lowlevel\lwip\cfg;..\..\..\..\..\libs\lowlevel\lwip\LwIP\system;..\..\..\..\..\libs\lowlevel\lwip\LwIP\src\include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: ..\cfg\amcmj1.1cm7-maintainer.sct
  link misc: --diag_suppress=L6329
  group main
    ../../../../common/env/dualcore/eUpdater/: updater-main.cpp
  group emaintainer-info
    ../src/: emaintainer-info.cpp
  group eupdater-code
    ../../../../../embot/hw/: hal_embot.cpp
    ../../../../common/env/dualcore/eUpdater/: eupdater_parser.cpp updater-core.cpp
  group stm32hal
    ../../../../../libs/lowlevel/stm32hal/lib/: stm32hal.h7.amcmj1.1cm7.v1B6.lib stm32hal.h7.amcmj1.2cm4.v1B6.lib
    ../../../../../libs/lowlevel/stm32hal/src/driver/stm32h7-v1A0/extra/: system_stm32h7xx-cm4-cm7-gated.c
    ../cfg/: stm32hal.h7.startup.amcmj1.s
  group rtos
    ../../../../../libs/highlevel/abslayer/osal/lib/: osal.cm4.dbg.lib
    ../../../../../libs/midware/eventviewer/src/: eventviewer.c
  group embot::core
    ../../../../../../../../../icub-firmware-shared/embot/core/: embot_core.cpp embot_core_binary.cpp embot_core_utils.cpp
  group embot::hw-core
    ../../../../../embot/hw/: embot_hw_bsp.cpp embot_hw.cpp embot_hw_gpio.cpp embot_hw_led.cpp embot_hw_sys.cpp embot_hw_can.cpp embot_hw_flash.cpp embot_hw_dualcore.cpp
  group embot::os
    ../../../../../embot/os/: embot_os.cpp embot_os_Action.cpp embot_os_theCallbackManager.cpp embot_os_theScheduler.cpp embot_os_theTimerManager.cpp embot_os_Thread.cpp embot_os_Timer.cpp embot_os_rtos.cpp embot_os_eom.cpp
  group embot::app
    ../../../../../embot/app/: embot_app_theLEDmanager.cpp embot_app_scope.cpp
    ../../../../../../../../../icub-firmware-shared/embot/tools/: embot_tools.cpp
  group embot::hw::lowlevel
    ../../../../../embot/hw/: embot_hw_lowlevel.cpp
  group embot::hw::bsp-core-cm7
    ../../../bsp/cm7/: embot_hw_bsp_amcmj1_1cm7.cpp
  group embot::hw::bsp-core-cm4
    ../../../bsp/cm4/: embot_hw_bsp_amcmj1_2cm4.cpp
  group embot::hw::bsp-core-shared
    ../../../bsp/shared/: embot_hw_dualcore_bsp_amcmj1.cpp embot_hw_gpio_bsp_amcmj1.cpp embot_hw_flash_bsp_amcmj1.cpp embot_hw_led_bsp_pinout_amcmj1.h embot_hw_led_bsp_amcmj1.cpp embot_hw_bsp_DRIVER_amcmj1.cpp
  group embot::hw::bsp-others
    ../../../bsp/portable/: embot_hw_eeprom_bsp_amcmj1.cpp embot_hw_spi_bsp_amcmj1.cpp embot_hw_can_bsp_amcmj1.cpp embot_hw_timer_bsp_amcmj1.cpp
  group embot::hw-others
    ../../../../../embot/hw/: embot_hw_eeprom.cpp embot_hw_eth.cpp embot_hw_spi.cpp embot_hw_chip_M95512DF.cpp embot_hw_chip_KSZ8563.cpp embot_hw_timer.cpp
  group embot:hw::eth::bsp
    ../../../bsp/portable/: embot_hw_eth_bsp_amcmj1.cpp
    ../../../bsp/portable/eth/: PHY_KSZ8563.c EMAC_STM32H7xx_KSZ8563.c ethram.c ipal_hal_eth_stm32h7.c
  group xtra->ipal
    ../../../../../libs/highlevel/abslayer/ipal/lib/: ipal.lwip.h7.cm4.lib
    ../cfg/: ipal_cfg2.cpp
  group xtra->eo-core
    ../../../../../../../../../icub-firmware-shared/eth/embobj/core/core/: EOaction.c EOarray.c EoCommon.c EOconstarray.c EOconstvector.c EOdeque.c EOfifo.c EOfifoByte.c EOfifoWord.c EOlist.c EOpacket.c EOsm.c EOtheErrorManager.c EOtheLEDpulser.c EOtheMemoryPool.c EOtimer.c EOumlsm.c EOvector.c EOVmutex.c EOVtask.c EOVtheCallbackManager.c EOVtheSystem.c EOVtheTimerManager.c
  group xtra->eo-mee-embot
    ../../../../../embobj/core/exec/multitask/embot/: EOMmutex.embot.cpp EOMtask.embot.cpp EOMtheCallbackManager.embot.cpp EOMtheSystem.embot.cpp EOMtheTimerManager.embot.cpp
  group xtra->eo-ipnet
    ../../../../../embobj/plus/ipnet/: EOMtheIPnet.c EOsocket.c EOsocketDatagram.c EOVtheIPnet.c
  group eo-updaterprotocol
    ../../../../../../../../../icub-firmware-shared/eth/embobj/plus/comm-v2/icub/: EoUpdaterProtocol.c
  group eo-theEnvironment
    ../../../../../embobj/plus/embenv/: EOtheARMenvironment.c EOVtheEnvironment.c
    ../../../../../libs/highlevel/services/embenv/src/: eEcommon.c eEsharedServices.c shalBASE.c shalINFO.c shalPART.c
  group lwip
    ../../../../../libs/lowlevel/lwip/lib/: lwip.6udp.9pkt.cm4.lib
    ../../../../../embot/net/: embot_net_eth_Packet.cpp embot_net_lwip.cpp
    ../../../../../embot/hw/: embot_hw_lwip.cpp
target amcmj1.maintainer.2cm4 (6230000::V6.23::ARMCLANG)
  device: STM32H747AIIx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x10000000,0x00048000) IROM(0x08100000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: amcmj1_emaintainer_cm4 +hex
  AfterMake: cmd.exe /C copy .\objcm4\amcmj1_emaintainer_cm4.hex ..\bin\amcmj1.maintainer.cm4.hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: _MAINTAINER_APPL_ STM32HAL_dualcore_BOOT_cm4master USE_STM32HAL STM32HAL_BOARD_AMCMJ1_2CM4 STM32HAL_DRIVER_V1B6 USE_EMBOT_HW EMBOT_HW_BSP__maintainer
  c misc: -DEMBOT_NET_LWIP_activated -DEMBOBJ_USE_EMBOT -Wno-pragma-pack -Wno-deprecated-register -DEMBOT_USE_rtos_osal  -DIPAL_use_cfg2 -Ddont_USE_IPADDR_FROM_IPAL_CFG_
  c include: ..\..\..\..\..\libs\lowlevel\stm32hal\api;..\..\..\..\..\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\embot\hw;..\..\..\..\..\embot\os;..\..\..\..\..\embot\app;..\..\..\..\..\libs\midware\eventviewer\api;..\..\..\..\..\libs\highlevel\services\embenv\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\tools;..\..\..\bsp\cm4;..\..\..\bsp\shared;..\..\..\bsp\portable\eth;..\..\..\..\..\libs\highlevel\abslayer\ipal\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core;..\..\..\..\..\embobj\core\exec\multitask;..\..\..\..\..\embobj\plus\ipnet;..\cfg;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\prot\eth;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\icub;..\..\..\..\..\libs\highlevel\services\embenv\api;..\..\..\..\..\embobj\plus\embenv;..\..\..\..\common\env\dualcore\eUpdater;..\..\..\..\..\libs\highlevel\abslayer\hal2\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\can\canProtocolLib;..\proj;..\..\..\..\common\env\dualcore\eUpdater;..\..\..\..\common\env\dualcore\info;..\..\..\..\..\embot\net;..\..\..\..\..\libs\lowlevel\lwip\cfg;..\..\..\..\..\libs\lowlevel\lwip\LwIP\system;..\..\..\..\..\libs\lowlevel\lwip\LwIP\src\include
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x48000
  scatter file: ..\cfg\amcmj1.2cm4-maintainer.sct
  link misc: --diag_suppress=L6329
