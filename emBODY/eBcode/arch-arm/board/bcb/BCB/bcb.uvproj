# Keil uVision project bcb.uvproj, settings and files
target BCB (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: bcb
  c flags: Optim=1
  c define: STM32F10X_MD
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ./: startup_stm32f10x_md.s system_stm32f10x.c
  group Main
    ./: bcb.c
  group Peripherals
    ./: gpio.c usart.c can.c adc.c stm32f10x_i2c.c stm32f10x_rcc.c bmon.c stm32f10x_gpio.c stm32f10x_dma.c
  group Interrupts
    ./: exti.c
  group Timers
    ./: timer.c
  group Documentation
    ./: Abstract.txt TEMP.txt TEMP1.txt
