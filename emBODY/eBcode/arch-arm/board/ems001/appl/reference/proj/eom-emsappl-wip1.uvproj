# Keil uVision project eom-emsappl-wip1.uvproj, settings and files
target emsappl-mcbstm32c-zerooffset (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: emsappl4mcbstm32c +hex
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=2
  c define: HAL_USE_ARCH_ARM EENV_EAPPLICATION_FORCE_CODE_OFFSET_TO_ZERO EO_USE_EPROT_V2
  c misc: --c99
  c include: ..\..\..\..\..\libs\abslayer\hal\api;..\..\..\..\..\libs\abslayer\ipal\api;..\..\..\..\..\libs\abslayer\osal\api;..\..\..\..\..\..\embobj\core\core;..\..\..\..\..\..\embobj\core\exec\multitask;..\..\..\..\..\..\embobj\plus\embenv;..\..\..\..\..\..\embobj\plus\ipnet;..\..\..\..\..\libs\services\embenv\api;..\..\..\..\..\libs\midware\eventviewer\api;..\app_main;..\app_cfg;..\abslayer-cfg;..\..\..\..\..\..\embobj\plus\ctrloop;..\..\..\env\cfg;..\..\..\..\..\..\embobj\plus\comm-v2\icub;..\..\..\..\..\..\embobj\plus\comm-v1\opcprot;..\..\..\..\..\..\embobj\plus\comm-v2\transport;..\..\..\..\..\..\embobj\plus\comm-v2\protocol\api;..\..\..\..\..\..\robotconfig\v1\eprotocol
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\eApplication-zerooffset.sct
  group app_main
    ../app_main/: eom_emsappl_main.c
  group abslayer-lib
    ../../../../../libs/abslayer/hal/lib/: hal.ems001.lib hal.mcbstm32c.lib
    ../../../../../libs/abslayer/hal/stg/: hal_startup_stm32f107.s
    ../../../../../libs/abslayer/ipal/lib/: ipal.base.medium.lib
    ../../../../../libs/abslayer/osal/lib/: osal.cm3.lib osal.cm3.dbg.lib
  group abslayer-cfg
    ../abslayer-cfg/: hal_cfg.c ipal_cfg.c osal_cfg.c hal_cfg.h ipal_cfg.h osal_cfg.h
  group eo-core
    ../../../../../../embobj/core/core/: EOpacket.c EOsm.c EOaction.c EOarray.c EoCommon.c EOconstarray.c EOconstvector.c EOdeque.c EOfifo.c EOfifoByte.c EOfifoWord.c EOlist.c EOtheErrorManager.c EOtheLEDpulser.c EOtheMemoryPool.c EOtimer.c EOumlsm.c EOvector.c EOVmutex.c EOVtask.c EOVtheCallbackManager.c EOVtheSystem.c EOVtheTimerManager.c
  group eo-mee
    ../../../../../../embobj/core/exec/multitask/: EOMmutex.c EOMtask.c EOMtheCallbackManager.c EOMtheSystem.c EOMtheTimerManager.c
  group eo-ipnet
    ../../../../../../embobj/plus/ipnet/: EOMtheIPnet.c EOsocket.c EOsocketDatagram.c EOVtheIPnet.c
  group eo-arm-env
    ../../../../../../embobj/plus/embenv/: EOtheARMenvironment.c EOVtheEnvironment.c
  group eventviewer
    ../../../../../libs/midware/eventviewer/src/: eventviewer.c
  group arm-services-embenv
    ../../../../../libs/services/embenv/src/: eEcommon.c eEsharedServices.c shalBASE.c shalINFO.c shalPART.c
  group eo-ctrloop
    ../../../../../../embobj/plus/ctrloop/: eOcfg_sm_EMSappl.c EOMtheEMSappl.c EOMtheEMSapplCfg.c EOMtheEMSbackdoor.c EOMtheEMSbackdoortransceiver.c EOMtheEMSconfigurator.c EOMtheEMSdiscoverylistener.c EOMtheEMSdiscoverytransceiver.c EOMtheEMSerror.c EOMtheEMSrunner.c EOMtheEMSsocket.c EOMtheEMStransceiver.c
  group eo-ctrloop-cfg
    ../app_cfg/: EOMtheEMSapplCfg_cfg.h example_overridden_appl.c example_overridden_configurator.c example_overridden_error.c example_overridden_runner.c overridden_backdoortransceiver.c
  group opc-protocol
    ../../../../../../embobj/plus/comm-v1/opcprot/: OPCprotocolManager.c
  group opc-protocol-cfg
    ../app_cfg/: OPCprotocolManager_Cfg.c
  group eo-comm-v2-transport
    ../../../../../../embobj/plus/comm-v2/transport/: EOagent.c EOconfirmationManager.c EOhostTransceiver.c EOnv.c EOnvSet.c EOproxy.c EOreceiver.c EOrop.c EOropframe.c EOtheBOARDtransceiver.c EOtheFormer.c EOtheParser.c EOtransceiver.c EOtransmitter.c
  group eo-comm-v2-protocol-boards
    ../../../../../../robotconfig/v1/eprotocol/: eOprot_b01.c eOprot_b02.c eOprot_b03.c eOprot_b04.c eOprot_b05.c eOprot_b06.c eOprot_b07.c eOprot_b08.c eOprot_b09.c
  group eo-comm-v2-protocol
    ../../../../../../embobj/plus/comm-v2/protocol/src/: EoProtocol.c EoProtocolAS_fun.c EoProtocolAS_rom.c EoProtocolEPs.c EoProtocolMC_fun.c EoProtocolMC_rom.c EoProtocolMN_fun.c EoProtocolMN_rom.c EoProtocolSK_fun.c EoProtocolSK_rom.c
  group eo-nvs-cfg-usrcbk
    ../app_cfg/: EoProtocolEPmn_fun_overridden.c EoProtocolEPmc_fun_overridden.c
  group nee
    ../../../../../../embobj/core/core/: EONtheSystem.c EONtheCallbackManager.c EONtheTimerManager.c EONtask.c EONmutex.c
target emsappl-mcbstm32c-normoffset (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: emsappl4mcbstm32c +hex
  c flags: Optim=1 OneElfS=1
  c define: EMSAPPL_USE_CORE HAL_USE_ARCH_ARM SHALS_MODE_STATIC _FORCE_NETWORK_FROM_IPAL_CFG
  c misc: --c99
  c include: ..\abslayer-cfg;..\app_main;..\app_cfg;..\..\..\..\sys\abs\api;..\..\..\..\sys\env\api;..\..\..\..\sys\mid\api;..\..\..\..\..\porting;..\..\..\..\..\any-arch\body\embenv\envcom;..\..\..\..\..\any-arch\sys\embobj\core\api;..\..\..\..\..\any-arch\sys\embobj\core\src;..\..\..\..\..\any-arch\sys\embobj\core-mee\api;..\..\..\..\..\any-arch\sys\embobj\core-mee\src;..\..\..\..\..\any-arch\sys\embobj\env\api;..\..\..\..\..\any-arch\sys\embobj\env\src;..\..\..\..\..\any-arch\sys\embobj\ipnet\api;..\..\..\..\..\any-arch\sys\embobj\ipnet\src;..\..\..\..\..\any-arch\sys\embobj\ipnet-mee\api;..\..\..\..\..\any-arch\sys\embobj\ipnet-mee\src;.;..\..\..\..\..\any-arch\sys\embobj\core-vee\api;..\..\..\..\..\any-arch\sys\embobj\core-vee\src;..\..\..\..\..\any-arch\sys\embobj\prot\src;..\..\..\..\..\any-arch\sys\embobj\prot\api;..\..\..\..\..\any-arch\sys\embobj\icub\api;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\board-eps;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-management\api;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-management\src;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-motioncontrol\api;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-motioncontrol\src;..\..\..\..\..\any-arch\sys\embobj\utils\api;..\..\..\..\..\any-arch\sys\embobj\utils\src;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-analogsensors\api;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-analogsensors\src;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-skin\api;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-skin\src;..\..\..\..\..\any-arch\sys\embobj\icub-app\api;..\..\..\..\..\any-arch\sys\embobj\icub-app\cfg;..\..\..\..\..\any-arch\sys\embobj\icub-app\src
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\eApplication.sct
target emsappl-ems001brd-normoffset (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: emsappl4mcbstm32c +hex
  c flags: Optim=1
  c define: EMSAPPL_USE_CORE HAL_USE_ARCH_ARM SHALS_MODE_STATIC
  c misc: --c99
  c include: as above
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\eApplication.sct
target emsappl-ems001brd-zerooffset (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: emsappl4mcbstm32c +hex
  c flags: Optim=1
  c define: EMSAPPL_USE_CORE HAL_USE_ARCH_ARM SHALS_MODE_STATIC EENV_EAPPLICATION_FORCE_CODE_OFFSET_TO_ZERO
  c misc: --c99
  c include: ..\app_main;..\app_cfg;..\abslayer-cfg;..\..\..\..\sys\abs\api;..\..\..\..\sys\env\api;..\..\..\..\sys\mid\api;..\..\..\..\..\porting;..\..\..\..\..\any-arch\body\embenv\envcom;..\..\..\..\..\any-arch\sys\embobj\core\api;..\..\..\..\..\any-arch\sys\embobj\core\src;..\..\..\..\..\any-arch\sys\embobj\core-mee\api;..\..\..\..\..\any-arch\sys\embobj\core-mee\src;..\..\..\..\..\any-arch\sys\embobj\env\api;..\..\..\..\..\any-arch\sys\embobj\env\src;..\..\..\..\..\any-arch\sys\embobj\ipnet\api;..\..\..\..\..\any-arch\sys\embobj\ipnet\src;..\..\..\..\..\any-arch\sys\embobj\ipnet-mee\api;..\..\..\..\..\any-arch\sys\embobj\ipnet-mee\src;..\..\..\..\..\any-arch\sys\embobj\core-vee\api;..\..\..\..\..\any-arch\sys\embobj\core-vee\src;..\..\..\..\..\any-arch\sys\embobj\prot\src;..\..\..\..\..\any-arch\sys\embobj\prot\api;..\..\..\..\..\any-arch\sys\embobj\icub\api;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\board-eps;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-management\api;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-management\src;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-motioncontrol\api;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-motioncontrol\src;..\..\..\..\..\any-arch\sys\embobj\utils\api;..\..\..\..\..\any-arch\sys\embobj\utils\src;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-analogsensors\api;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-analogsensors\src;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-skin\api;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-skin\src;..\..\..\..\..\any-arch\sys\embobj\icub-app\api;..\..\..\..\..\any-arch\sys\embobj\icub-app\cfg;..\..\..\..\..\any-arch\sys\embobj\icub-app\src
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\eApplication-zerooffset.sct
