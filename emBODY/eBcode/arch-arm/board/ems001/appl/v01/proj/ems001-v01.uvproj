# Keil uVision project ems001-v01.uvproj, settings and files
target emsappl-mcbstm32c-zerooffset (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: emsappl4mcbstm32c +hex
  c flags: Optim=1
  c define: HAL_USE_ARCH_ARM EENV_EAPPLICATION_FORCE_CODE_OFFSET_TO_ZERO
  c misc: --c99
  c include: .;..\app_main;..\app_cfg;..\app_nvs_cfg;..\abslayer-cfg;..\..\..\..\sys\abs\api;..\..\..\..\sys\env\api;..\..\..\..\sys\mid\api;..\..\..\..\..\porting;..\..\..\..\..\any-arch\body\embenv\envcom;..\..\..\..\..\any-arch\sys\embobj\core\api;..\..\..\..\..\any-arch\sys\embobj\core\src;..\..\..\..\..\any-arch\sys\embobj\core-mee\api;..\..\..\..\..\any-arch\sys\embobj\core-mee\src;..\..\..\..\..\any-arch\sys\embobj\env\api;..\..\..\..\..\any-arch\sys\embobj\env\src;..\..\..\..\..\any-arch\sys\embobj\ipnet\api;..\..\..\..\..\any-arch\sys\embobj\ipnet\src;..\..\..\..\..\any-arch\sys\embobj\ipnet-mee\api;..\..\..\..\..\any-arch\sys\embobj\ipnet-mee\src;..\..\..\..\..\any-arch\sys\embobj\core-vee\api;..\..\..\..\..\any-arch\sys\embobj\core-vee\src;..\..\..\..\..\any-arch\sys\embobj\prot\src;..\..\..\..\..\any-arch\sys\embobj\prot\api;..\..\..\..\..\any-arch\sys\embobj\icub\api;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\board-eps;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-management\api;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-management\src;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-motioncontrol\api;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-motioncontrol\src;..\..\..\..\..\any-arch\sys\embobj\utils\api;..\..\..\..\..\any-arch\sys\embobj\utils\src;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-analogsensors\api;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-analogsensors\src;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-skin\api;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-skin\src;..\..\..\..\..\any-arch\sys\embobj\icub-app\api;..\..\..\..\..\any-arch\sys\embobj\icub-app\src
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\eApplication-zerooffset.sct
  group app_main
    ../app_main/: eom_emsappl_main.c
  group abslayer-lib
    ../../../../../libs/abslayer/hal/lib/: hal.ems001.lib
    ../../../../../libs/abslayer/hal/stg/: hal_startup_stm32f107.s
    ../../../../../libs/abslayer/osal/lib/: osal.cm3.lib osal.cm3.dbg.lib
    ../../../../../libs/abslayer/ipal/lib/: ipal.base.medium.lib
  group abslayer-cfg
    ../abslayer-cfg/: osal_cfg.h hal_cfg.h ipal_cfg.h osal_cfg.c hal_cfg.c ipal_cfg.c
  group eo-core
    ../../../../../../embobj/core/core/: EOaction.c EOarray.c EoCommon.c EOconstarray.c EOconstvector.c EOdeque.c EOfifo.c EOfifoByte.c EOfifoWord.c EOlist.c EOpacket.c EOsm.c EOtheErrorManager.c EOtheLEDpulser.c EOtheMemoryPool.c EOtimer.c EOumlsm.c EOvector.c EOVmutex.c EOVtask.c EOVtheCallbackManager.c EOVtheSystem.c EOVtheTimerManager.c
  group eo-core-mee
    ../../../../../../embobj/core/exec/multitask/: EOMmutex.c EOMtask.c EOMtheCallbackManager.c EOMtheSystem.c EOMtheTimerManager.c
  group eo-ipnet
    ../../../../../../embobj/plus/ipnet/: EOMtheIPnet.c EOsocket.c EOsocketDatagram.c EOVtheIPnet.c
  group eo-arm-env
    ../../../../../../embobj/plus/embenv/: EOtheARMenvironment.c EOVtheEnvironment.c
  group eventviewer
    ../../../../../libs/midware/eventviewer/src/: eventviewer.c
  group arm-services-embenv
    ../../../../../libs/services/embenv/src/: eEcommon.c eEsharedServices.c shalBASE.c shalINFO.c shalPART.c
  group eo-ctrloop
    ../../../../../../embobj/plus/ctrloop/: eOcfg_sm_EMSappl.c EOMtheEMSappl.c EOMtheEMSapplCfg.c EOMtheEMSbackdoor.c EOMtheEMSbackdoortransceiver.c EOMtheEMSconfigurator.c EOMtheEMSdiscoverylistener.c EOMtheEMSdiscoverytransceiver.c EOMtheEMSerror.c EOMtheEMSrunner.c EOMtheEMSsocket.c EOMtheEMStransceiver.c
  group eo-ctrloop-cfg
    ../app_cfg/: EOMtheEMSapplCfg_cfg.h overridden_runner.c overridden_appl.c overridden_sm.c overridden_configurator.c overridden_backdoortransceiver.c overridden_error.c
  group opc-protocol
    ../../../../../../embobj/plus/comm-v1/opcprot/: OPCprotocolManager.c
  group opc-protocol-cfg
    ../../../../../../robotconfig/v1/backdoor/: OPCprotocolManager_Cfg.c
  group eo-comm-prot
    ../../../../../../embobj/plus/comm-v1/prot/: EOmatrix3d.c EOnv.c EOnvsCfg.c EOreceiver.c EOrop.c EOropframe.c EOtheAgent.c EOtheBOARDtransceiver.c EOtheFormer.c EOtheParser.c EOtransceiver.c EOtransmitter.c EOtreenode.c EOVstorage.c
  group eo-comm-nvs-boards
    ../../../../../../embobj/plus/comm-v1/nvs/board-eps/: eOcfg_EPs_eb1.c eOcfg_EPs_eb2.c eOcfg_EPs_eb3.c eOcfg_EPs_eb4.c eOcfg_EPs_eb5.c eOcfg_EPs_eb6.c eOcfg_EPs_eb7.c eOcfg_EPs_eb8.c eOcfg_EPs_eb9.c
  group eo-comm-nvs-ep-as
    ../../../../../../embobj/plus/comm-v1/nvs/ep-analogsensors/: eOcfg_nvsEP_as.c eOcfg_nvsEP_as_any_con_body.c eOcfg_nvsEP_as_any_con_mxx.c eOcfg_nvsEP_as_any_con_mxxdefault.c eOcfg_nvsEP_as_any_con_sxx.c eOcfg_nvsEP_as_any_con_sxxdefault.c eOcfg_nvsEP_as_onemais_con.c eOcfg_nvsEP_as_onemais_usr.c eOcfg_nvsEP_as_onestrain_con.c eOcfg_nvsEP_as_onestrain_usr.c
  group eo-comm-nvs-ep-mc
    ../../../../../../embobj/plus/comm-v1/nvs/ep-motioncontrol/: eOcfg_nvsEP_mc.c eOcfg_nvsEP_mc_any_con_bodypart.c eOcfg_nvsEP_mc_any_con_cxx.c eOcfg_nvsEP_mc_any_con_cxxdefault.c eOcfg_nvsEP_mc_any_con_jxx.c eOcfg_nvsEP_mc_any_con_jxxdefault.c eOcfg_nvsEP_mc_any_con_mxx.c eOcfg_nvsEP_mc_any_con_mxxdefault.c eOcfg_nvsEP_mc_lowerarm_con.c eOcfg_nvsEP_mc_lowerarm_usr.c eOcfg_nvsEP_mc_lowerleg_con.c eOcfg_nvsEP_mc_lowerleg_usr.c eOcfg_nvsEP_mc_torso_con.c eOcfg_nvsEP_mc_torso_usr.c eOcfg_nvsEP_mc_upperarm_con.c eOcfg_nvsEP_mc_upperarm_usr.c eOcfg_nvsEP_mc_upperleg_con.c eOcfg_nvsEP_mc_upperleg_usr.c
  group eo-comm-nvs-ep-mn
    ../../../../../../embobj/plus/comm-v1/nvs/ep-management/: eOcfg_nvsEP_mn.c eOcfg_nvsEP_mn_appl_con.c eOcfg_nvsEP_mn_appl_usr.c eOcfg_nvsEP_mn_comm_con.c eOcfg_nvsEP_mn_comm_usr.c
  group eo-comm-nvs-ep-sk
    ../../../../../../embobj/plus/comm-v1/nvs/ep-skin/: eOcfg_nvsEP_sk.c eOcfg_nvsEP_sk_emsboard_con.c eOcfg_nvsEP_sk_emsboard_usr.c
  group appl-services-provider
    ../app_servicesProviders_obj/: EOappCanServicesProvider.c EOappEncodersReader.c EOappMeasuresConverter.c EOappTheDataBase.c EOtheEMSapplBody.c
  group appl-services-provider-cfg
    ../app_servicesProviders_cfg/icub-can-proto/: eOcfg_icubCanProto_messagesLookupTbl.c eOcfg_icubCanProto_motorBoardMsgFunctions.c eOcfg_icubCanProto_motorBoardMsgLookupTbl.c eOcfg_icubCanProto_sensorBoardMsgFunctions.c eOcfg_icubCanProto_sensorBoardMsgLookupTbl.c
    ../app_servicesProviders_cfg/measures-converter/: measuresConvFuncOveridden.c
    ../app_servicesProviders_cfg/icub-can-net/: eOcfg_appTheDataBase_ebx.c
  group eo-nvs-cfg-usrcbk
    ../app_nvs_cfg/: eOcfg_nvsEP_as_usrcbk_ebx.c eOcfg_nvsEP_mn_comm_usrcbk_ebx.c eOcfg_nvsEP_sk_usrcbk_ebx.c eOcfg_nvsEP_mc_usrcbk_ebx.c rxtools.c
  group eo-ems-can
    ../../../../../../embobj/plus/board/ems001/: EOicubCanProto.c
  group eo-motor-controller
    ../../../../../../embobj/plus/mc/: EOaxisController.c EOdecoupler.c EOemsController.c EOpid.c EOspeedmeter.c EOtrajectory.c
  group ethLowLevelParserDebug
    ../ethlowlevelparser/: usrCbk_ethLowLevParser.c
    ../../../../../../embobj/plus/utils/: eODeb_eoProtoParser.c eOtheEthLowLevelParser.c
  group diagnostics
    ../../../../../../embobj/plus/board/ems001/: EOtheEMSapplDiagnostics.c
    ../app_cfg/: userdef_onerror.c
target emsappl-mcbstm32c-normoffset (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: emsappl4mcbstm32c +hex
  c flags: Optim=1 OneElfS=1
  c define: HAL_USE_ARCH_ARM _FORCE_NETWORK_FROM_IPAL_CFG
  c misc: --c99
  c include: ..\abslayer-cfg;..\app_main;..\app_cfg;..\app_nvs_cfg;..\..\..\..\sys\abs\api;..\..\..\..\sys\env\api;..\..\..\..\sys\mid\api;..\..\..\..\..\porting;..\..\..\..\..\any-arch\body\embenv\envcom;..\..\..\..\..\any-arch\sys\embobj\core\api;..\..\..\..\..\any-arch\sys\embobj\core\src;..\..\..\..\..\any-arch\sys\embobj\core-mee\api;..\..\..\..\..\any-arch\sys\embobj\core-mee\src;..\..\..\..\..\any-arch\sys\embobj\env\api;..\..\..\..\..\any-arch\sys\embobj\env\src;..\..\..\..\..\any-arch\sys\embobj\ipnet\api;..\..\..\..\..\any-arch\sys\embobj\ipnet\src;..\..\..\..\..\any-arch\sys\embobj\ipnet-mee\api;..\..\..\..\..\any-arch\sys\embobj\ipnet-mee\src;.;..\..\..\..\..\any-arch\sys\embobj\core-vee\api;..\..\..\..\..\any-arch\sys\embobj\core-vee\src;..\..\..\..\..\any-arch\sys\embobj\prot\src;..\..\..\..\..\any-arch\sys\embobj\prot\api;..\..\..\..\..\any-arch\sys\embobj\icub\api;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\board-eps;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-management\api;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-management\src;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-motioncontrol\api;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-motioncontrol\src;..\..\..\..\..\any-arch\sys\embobj\utils\api;..\..\..\..\..\any-arch\sys\embobj\utils\src;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-analogsensors\api;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-analogsensors\src;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-skin\api;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-skin\src;..\..\..\..\..\any-arch\sys\embobj\icub-app\api;..\..\..\..\..\any-arch\sys\embobj\icub-app\cfg;..\..\..\..\..\any-arch\sys\embobj\icub-app\src
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\eApplication.sct
target emsappl-ems001brd-normoffset (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: emsappl4emsbrd_normalOffsetV01 +hex
  c flags: Optim=4 OneElfS=1
  c define: HAL_USE_ARCH_ARM
  c misc: --c99
  c include: ..\app_main;..\app_cfg;..\app_nvs_cfg;..\app_servicesProviders_obj;..\app_servicesProviders_cfg\icub-can-net;..\app_servicesProviders_cfg\icub-can-proto;..\abslayer-cfg;..\..\..\..\sys\abs\api;..\..\..\..\sys\env\api;..\..\..\..\sys\mid\api;..\..\..\..\..\porting;..\..\..\..\..\any-arch\body\embenv\envcom;..\..\..\..\..\any-arch\sys\embobj\core\api;..\..\..\..\..\any-arch\sys\embobj\core\src;..\..\..\..\..\any-arch\sys\embobj\core-mee\api;..\..\..\..\..\any-arch\sys\embobj\core-mee\src;..\..\..\..\..\any-arch\sys\embobj\env\api;..\..\..\..\..\any-arch\sys\embobj\env\src;..\..\..\..\..\any-arch\sys\embobj\ipnet\api;..\..\..\..\..\any-arch\sys\embobj\ipnet\src;..\..\..\..\..\any-arch\sys\embobj\ipnet-mee\api;..\..\..\..\..\any-arch\sys\embobj\ipnet-mee\src;..\..\..\..\..\any-arch\sys\embobj\core-vee\api;..\..\..\..\..\any-arch\sys\embobj\core-vee\src;..\..\..\..\..\any-arch\sys\embobj\prot\src;..\..\..\..\..\any-arch\sys\embobj\prot\api;..\..\..\..\..\any-arch\sys\embobj\icub\api;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\board-eps;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-management\api;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-management\src;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-motioncontrol\api;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-motioncontrol\src;..\..\..\..\..\any-arch\sys\embobj\utils\api;..\..\..\..\..\any-arch\sys\embobj\utils\src;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-analogsensors\api;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-analogsensors\src;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-skin\api;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-skin\src;..\..\..\..\..\any-arch\sys\embobj\icub-app\api;..\..\..\..\..\any-arch\sys\embobj\icub-app\cfg;..\..\..\..\..\any-arch\sys\embobj\icub-app\src;..\..\..\..\..\any-arch\sys\embobj\icub-ems\api;..\..\..\..\..\any-arch\sys\embobj\icub-ems\src;..\..\..\..\..\any-arch\sys\embobj\mc\src;..\..\..\..\..\any-arch\sys\embobj\mc\api
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\eApplication.sct
target emsappl-ems001brd-zerooffset (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: emsappl4mcbstm32c +hex
  c flags: Optim=4 OneElfS=1
  c define: HAL_USE_ARCH_ARM EENV_EAPPLICATION_FORCE_CODE_OFFSET_TO_ZERO _FORCE_NETWORK_FROM_IPAL_CFG EVIEWER_ENABLED
  c misc: --c99
  c include: ..\app_main;..\app_cfg;..\app_nvs_cfg;..\app_servicesProviders_obj;..\app_servicesProviders_cfg\icub-can-net;..\app_servicesProviders_cfg\icub-can-proto;..\abslayer-cfg;..\..\..\..\sys\abs\api;..\..\..\..\sys\env\api;..\..\..\..\sys\mid\api;..\..\..\..\..\porting;..\..\..\..\..\any-arch\body\embenv\envcom;..\..\..\..\..\any-arch\sys\embobj\core\api;..\..\..\..\..\any-arch\sys\embobj\core\src;..\..\..\..\..\any-arch\sys\embobj\core-mee\api;..\..\..\..\..\any-arch\sys\embobj\core-mee\src;..\..\..\..\..\any-arch\sys\embobj\env\api;..\..\..\..\..\any-arch\sys\embobj\env\src;..\..\..\..\..\any-arch\sys\embobj\ipnet\api;..\..\..\..\..\any-arch\sys\embobj\ipnet\src;..\..\..\..\..\any-arch\sys\embobj\ipnet-mee\api;..\..\..\..\..\any-arch\sys\embobj\ipnet-mee\src;..\..\..\..\..\any-arch\sys\embobj\core-vee\api;..\..\..\..\..\any-arch\sys\embobj\core-vee\src;..\..\..\..\..\any-arch\sys\embobj\prot\src;..\..\..\..\..\any-arch\sys\embobj\prot\api;..\..\..\..\..\any-arch\sys\embobj\icub\api;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\board-eps;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-management\api;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-management\src;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-motioncontrol\api;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-motioncontrol\src;..\..\..\..\..\any-arch\sys\embobj\utils\api;..\..\..\..\..\any-arch\sys\embobj\utils\src;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-analogsensors\api;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-analogsensors\src;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-skin\api;..\..\..\..\..\any-arch\sys\embobj\icub-nvscfg\ep-skin\src;..\..\..\..\..\any-arch\sys\embobj\icub-app\api;..\..\..\..\..\any-arch\sys\embobj\icub-app\cfg;..\..\..\..\..\any-arch\sys\embobj\icub-app\src;..\..\..\..\..\any-arch\sys\embobj\mc\src;..\..\..\..\..\any-arch\sys\embobj\mc\api;..\..\..\..\..\any-arch\sys\embobj\icub-ems\api;..\..\..\..\..\any-arch\sys\embobj\icub-ems\src
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\eApplication-zerooffset.sct
target emsappl-ems-zerooffset-openosal (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: emsappl-0offset +hex
  c flags: Optim=1 OneElfS=1
  c define: as above
  c misc: --c99
  c include: as above
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\eApplication-zerooffset.sct
target esmappl-ems-normaloffset-openosal (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: emsappl4emsbrd_normalOffsetV01open +hex
  AfterMake: cmd.exe /C copy .\Obj\emsappl4emsbrd_normalOffsetV01open.hex ..\bin\emsappl.hex
  c flags: Optim=4 OneElfS=1
  c define: HAL_USE_ARCH_ARM
  c misc: --c99
  c include: as above
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\eApplication.sct
target ems001 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: ems001 +hex
  AfterMake: cmd.exe /C copy .\Obj\ems001.hex ..\bin\ems001.hex
  c flags: Optim=4 OneElfS=1
  c define: HAL_USE_ARCH_ARM
  c misc: --c99
  c include: ..\..\..\..\..\libs\abslayer\hal\api;..\..\..\..\..\libs\abslayer\ipal\api;..\..\..\..\..\libs\abslayer\osal\api;..\..\..\..\..\..\embobj\core\core;..\..\..\..\..\..\embobj\core\exec\multitask;..\..\..\..\..\..\embobj\plus\embenv;..\..\..\..\..\..\embobj\plus\ipnet;..\..\..\..\..\libs\services\embenv\api;..\..\..\..\..\libs\midware\eventviewer\api;..\app_main;..\app_cfg;..\abslayer-cfg;..\..\..\..\..\..\embobj\plus\ctrloop;..\..\..\..\..\..\embobj\plus\comm-v1\icub;..\..\..\..\..\..\embobj\plus\comm-v1\prot;..\..\..\..\..\..\embobj\plus\comm-v1\nvs\board-eps;..\..\..\..\..\..\embobj\plus\comm-v1\nvs\ep-analogsensors;..\..\..\..\..\..\embobj\plus\comm-v1\nvs\ep-motioncontrol;..\..\..\..\..\..\embobj\plus\comm-v1\nvs\ep-management;..\..\..\..\..\..\embobj\plus\comm-v1\nvs\ep-skin;.;..\..\..\..\..\..\embobj\plus\board\ems001;..\..\..\..\..\..\embobj\plus\mc;..\..\..\..\..\..\embobj\plus\utils;.;..\app_nvs_cfg;..\app_servicesProviders_obj;..\app_servicesProviders_cfg\icub-can-proto;..\app_servicesProviders_cfg\icub-can-net;..\..\..\env\cfg;..\..\..\..\..\..\robotconfig\v1\backdoor;..\..\..\..\..\..\embobj\plus\comm-v1\opcprot
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\eApplication.sct
target ems001-0offset (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: ems001.0o.hex +hex
  AfterMake: cmd.exe /C copy .\Obj\ems001.0o.hex ..\bin\ems001.0o.hex
  c flags: Optim=1 OneElfS=1
  c define: HAL_USE_ARCH_ARM EENV_EAPPLICATION_FORCE_CODE_OFFSET_TO_ZERO _FORCE_NETWORK_FROM_IPAL_CFG
  c misc: --c99
  c include: as above
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\eApplication.sct
