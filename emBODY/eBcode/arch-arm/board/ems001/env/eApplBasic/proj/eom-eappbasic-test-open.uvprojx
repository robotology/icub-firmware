# Keil uVision project eom-eappbasic-test-open.uvprojx, settings and files
target mcbstm32c (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: eapp-test-mcb +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: HAL_USE_ARCH_ARM
  c misc: -DemBODYrobot_ROBOT_NAME=iCubANY -DemBODYrobot_BOARD_NAME=boardEMS001 -DemBODYrobot_BOARD_NUMBER=boardnumberANY
  c include: ..\..\..\..\..\libs\highlevel\abslayer\hal\api;..\..\..\..\..\libs\highlevel\abslayer\ipal\api;..\..\..\..\..\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\embobj\core\core;..\..\..\..\..\..\embobj\core\exec\multitask;..\..\..\..\..\..\embobj\plus\embenv;..\..\..\..\..\..\embobj\plus\ipnet;..\..\cfg;..\..\..\..\..\libs\highlevel\services\embenv\api;..\..\..\..\..\libs\midware\eventviewer\api;..\app_extra;..\app_basic;..\..\..\..\..\..\robotconfig
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\eApplication.sct
  group app-basic
    ../app_basic/: eom_applbasic_main.c eom_applbasic_info.c eom_applbasic_specialise.c
    ../app_extra/: eom_applbasic_extra.c
  group abslayer-lib
    ../../../../../libs/highlevel/abslayer/hal/stg/: hal_startup_stm32f107.s
    ../../../../../libs/highlevel/abslayer/hal/lib/: hal.ems001.lib hal.mcbstm32c.lib
    ../../../../../libs/highlevel/abslayer/osal/lib/: osal.cm3.lib
    ../../../../../libs/highlevel/abslayer/ipal/lib/: ipal.base.medium.lib
  group abslayer-cfg
    ../abslayer-cfg/: hal_cfg.c ipal_cfg.c osal_cfg-open.c hal_cfg.h ipal_cfg.h osal_cfg-open.h
  group eo-core
    ../../../../../../embobj/core/core/: EOaction.c EOarray.c EoCommon.c EOconstarray.c EOconstvector.c EOdeque.c EOfifo.c EOfifoByte.c EOfifoWord.c EOlist.c EOpacket.c EOsm.c EOtheErrorManager.c EOtheMemoryPool.c EOtimer.c EOumlsm.c EOvector.c EOVmutex.c EOVtask.c EOVtheCallbackManager.c EOVtheSystem.c EOVtheTimerManager.c
  group eo-mee
    ../../../../../../embobj/core/exec/multitask/: EOMmutex.c EOMtask.c EOMtheCallbackManager.c EOMtheSystem.c EOMtheTimerManager.c
    ../../../../../../embobj/core/core/: EOtheLEDpulser.c
  group eo-ipnet
    ../../../../../../embobj/plus/ipnet/: EOMtheIPnet.c EOsocket.c EOsocketDatagram.c EOVtheIPnet.c
  group eo-arm-env
    ../../../../../../embobj/plus/embenv/: EOtheARMenvironment.c EOVtheEnvironment.c
  group eventviewer
    ../../../../../libs/midware/eventviewer/src/: eventviewer.c
  group arm-services-embenv
    ../../../../../libs/highlevel/services/embenv/src/: eEcommon.c eEsharedServices.c shalBASE.c shalINFO.c shalPART.c
  group embody-robot
    ../../../../../../robotconfig/: emBODYrobot.c
target ems001 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: eApplBasic_ems001_open +hex
  AfterMake: cmd.exe /C copy .\Obj\eApplBasic_ems001_open.hex ..\bin\eApplBasic_ems001_open.hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: HAL_USE_ARCH_ARM DONT_ARM DONT_USE_IPADDR_FROM_IPAL_CFG_
  c misc: as above
  c include: as above
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\eApplication.sct
software components: CMSIS:CORE 3.30.0
