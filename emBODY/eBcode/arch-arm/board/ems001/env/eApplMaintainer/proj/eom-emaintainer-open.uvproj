# Keil uVision project eom-emaintainer-open.uvproj, settings and files
target mcbstm32c (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: eomeupdater-updt +hex
  c flags: Optim=1
  c define: HAL_USE_ARCH_ARM _MAINTAINER_APPL_
  c misc: --c99
  c include: ..\abslayer-cfg;..\app_basic;..\..\..\..\sys\abs\api;..\..\..\..\sys\env\api;..\app_extra;..\..\..\..\sys\mid\api;..\..\..\..\..\porting;..\..\..\..\..\any-arch\body\embenv\envcom;..\..\..\..\..\any-arch\sys\embobj\core\api;..\..\..\..\..\any-arch\sys\embobj\core\src;..\..\..\..\..\any-arch\sys\embobj\core-mee\api;..\..\..\..\..\any-arch\sys\embobj\core-mee\src;..\..\..\..\..\any-arch\sys\embobj\env\api;..\..\..\..\..\any-arch\sys\embobj\env\src;..\..\..\..\..\any-arch\sys\embobj\ipnet\api;..\..\..\..\..\any-arch\sys\embobj\ipnet\src;..\..\..\..\..\any-arch\sys\embobj\ipnet-mee\api;..\..\..\..\..\any-arch\sys\embobj\ipnet-mee\src;.;..\..\..\..\..\any-arch\sys\embobj\core-vee\api;..\..\..\..\..\any-arch\sys\embobj\core-vee\src;..\..\EOMeUpdater.updt\app;..\..\EOMeApplMaintainer\app
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\eApplication.sct
  group app-shared-with-updater
    ../../EOMeUpdater.updt/app/: eom-eupdater-main.c eupdater_parser.c updater-core.c
  group app-only-for-maintainer
    ../app/: emaintainer-info.c
  group abslayer-lib
    ../../../../sys/abs/lib/: osal.open.cm3.lib hal.stm32f1.mcbstm32c.lib hal.stm32f1.ems001.lib ipal.base.medium.lib
    ../../../../sys/abs/src/: hal_stm32f1_startup.s
  group abslayer-cfg
    ../abslayer-cfg/: hal_cfg.c ipal_cfg.c osal_cfg-open.c hal_cfg.h ipal_cfg.h osal_cfg-open.h
  group eo-core
    ../../../../../any-arch/sys/embobj/core/src/: EoCommon.c EOtheErrorManager.c EOtheMemoryPool.c EOaction.c EOdeque.c EOfifo.c EOfifoByte.c EOfifoWord.c EOlist.c EOtimer.c EOvector.c EOarray.c EOconstarray.c EOconstvector.c
    ../../../../../any-arch/sys/embobj/core-vee/src/: EOVtheSystem.c EOVtheTimerManager.c EOVtheCallbackManager.c EOVtask.c EOVmutex.c
  group eo-mee
    ../../../../../any-arch/sys/embobj/core-mee/src/: EOMmutex.c EOMtask.c EOMtheCallbackManager.c EOMtheSystem.c EOMtheTimerManager.c
  group eo-ipnet
    ../../../../../any-arch/sys/embobj/ipnet/src/: EOpacket.c EOsocket.c EOsocketDatagram.c EOVtheIPnet.c
    ../../../../../any-arch/sys/embobj/ipnet-mee/src/: EOMtheIPnet.c
  group eo-arm-env
    ../../../../../any-arch/sys/embobj/env/src/: EOtheARMenvironment.c EOVtheEnvironment.c
  group ee-arm-shared-services
    ../../../../sys/env/src/: eEsharedServices.c shalBASE.c shalPART.c shalINFO.c
  group ee-any-arch
    ../../../../../any-arch/body/embenv/envcom/: eEcommon.c
target ems001 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: eMaintainer_ems001_open +hex
  AfterMake: cmd.exe /C copy .\Obj\eMaintainer_ems001_open.hex ..\bin\eMaintainer_ems001_open.hex
  c flags: Optim=1 OneElfS=1
  c define: HAL_USE_ARCH_ARM _MAINTAINER_APPL_
  c misc: --c99
  c include: as above
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\eApplication.sct
