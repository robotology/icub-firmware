# Keil uVision project eLoader.updt.sharserv.uvproj, settings and files
target mcbstm32c-sharlib (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: eLoader-updt +hex
  c flags: Optim=1 OneElfS=1
  c define: HAL_USE_ARCH_ARM SHARSERV_MODE_SHALIB BOARD_MCBSTM32C
  c misc: --c99
  c include: ..\..\..\..\sys\abs\api;..\..\..\..\sys\env\api;..\..\..\..\..\any-arch\body\embenv\envcom;..\..\..\..\..\porting;..\..\..\..\sys\env\api
  asm misc: --cpreproc
  asm include: ..\app
  memory RVCT4: ROM 0x8000000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\eLoader.sct
  group application
    ../app/: loader_updt.c
  group hal
    ../app/: hal_cfg.h hal_cfg.c
    ../../../../sys/abs/lib/: hal.stm32f1.ems001.lib hal.stm32f1.mcbstm32c.lib
    ../../../../sys/abs/src/: hal_stm32f1_startup.s
  group ee-arm-shared-services
    ../../../../body/embenv/envshalib/shalib/sharserv/lib/: sharSERV.ems001.obj sharSERV.mcbstm32c.obj
  group ee-any-arch
    ../../../../../any-arch/body/embenv/envcom/: eEcommon.c
target ems001-sharlib (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: eLoader_ems001 +hex
  c flags: Optim=1 OneElfS=1
  c define: HAL_USE_ARCH_ARM SHARSERV_MODE_SHALIB BOARD_EMS001
  c misc: --c99
  c include: ..\..\..\..\sys\abs\api;..\..\..\..\sys\env\api;..\..\..\..\..\any-arch\body\embenv\envcom;..\..\..\..\..\porting
  asm misc: --cpreproc
  asm include: ..\app
  memory RVCT4: ROM 0x8000000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\eLoader.sct
