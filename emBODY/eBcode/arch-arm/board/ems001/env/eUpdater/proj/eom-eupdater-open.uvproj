# Keil uVision project eom-eupdater-open.uvproj, settings and files
target mcbstm32c (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: eomeupdater-updt +hex
  c flags: Optim=4 OneElfS=1
  c define: HAL_USE_ARCH_ARM
  c misc: --c99
  c include: ..\..\..\..\..\libs\abslayer\hal\api;..\..\..\..\..\libs\abslayer\ipal\api;..\..\..\..\..\libs\abslayer\osal\api;..\..\..\..\..\..\embobj\core\core;..\..\..\..\..\..\embobj\core\exec\multitask;..\..\..\..\..\..\embobj\plus\embenv;..\..\..\..\..\..\embobj\plus\ipnet;..\..\cfg;..\..\..\..\..\libs\services\embenv\api
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\eUpdater.sct
  group app
    ../app/: eom-eupdater-main.c eupdater-info.c eupdater_parser.c updater-core.c eOcfg_sm_cangtw.c eupdater_cangtw.c
  group abslayer-lib
    ../../../../../libs/abslayer/hal/stg/: hal_startup_stm32f107.s
    ../../../../../libs/abslayer/hal/lib/: hal.ems001.lib hal.mcbstm32c.lib
    ../../../../../libs/abslayer/osal/lib/: osal.cm3.lib
    ../../../../../libs/abslayer/ipal/lib/: ipal.base.medium.lib
  group abslayer-cfg
    ../abslayer-cfg/: hal_cfg.c ipal_cfg.c osal_cfg-open.c hal_cfg.h ipal_cfg.h osal_cfg-open.h
  group eo-core
    ../../../../../../embobj/core/core/: EOaction.c EOarray.c EoCommon.c EOconstarray.c EOconstvector.c EOdeque.c EOfifo.c EOfifoByte.c EOfifoWord.c EOlist.c EOpacket.c EOsm.c EOtheErrorManager.c EOtheMemoryPool.c EOtimer.c EOumlsm.c EOvector.c EOVmutex.c EOVtask.c EOVtheCallbackManager.c EOVtheSystem.c EOVtheTimerManager.c
  group eo-mee
    ../../../../../../embobj/core/exec/multitask/: EOMmutex.c EOMtask.c EOMtheCallbackManager.c EOMtheSystem.c EOMtheTimerManager.c
  group eo-ipnet
    ../../../../../../embobj/plus/ipnet/: EOMtheIPnet.c EOsocket.c EOsocketDatagram.c EOVtheIPnet.c
  group eo-arm-env
    ../../../../../../embobj/plus/embenv/: EOtheARMenvironment.c EOVtheEnvironment.c
  group arm-services-embenv
    ../../../../../libs/services/embenv/src/: eEcommon.c eEsharedServices.c shalBASE.c shalINFO.c shalPART.c
target ems001 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: eUpdaterCANgtw_ems001_open +hex
  AfterMake: cmd.exe /C copy .\Obj\eUpdaterCANgtw_ems001_open.hex ..\bin\eUpdaterCANgtw_ems001_open.hex
  c flags: Optim=4 oTime=1 OneElfS=1
  c define: HAL_USE_ARCH_ARM BOARD_EMS001 DONT_USE_IPADDR_FROM_IPAL_CFG_
  c misc: --c99
  c include: as above
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\eUpdater.sct
