# Keil uVision project ems.test.uvprojx, settings and files
target ems-ulpro (6190000::V6.19::ARMCLANG)
  device: STM32F407IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: ems004 +hex
  AfterMake: cmd.exe /C copy .\Obj\ems004.hex ..\bin\ems.hex
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: USE_STM32HAL USE_hal2_DRIVER STM32HAL_BOARD_EMS EMBOT_USE_rtos_osal
  c misc: -Wno-pragma-pack -Wno-deprecated-register -DxUSE_EMS4RD
  c include: ..\..\..\..\..\libs\highlevel\abslayer\osal\api;..\cfg\abslayer;..\..\..\..\..\libs\midware\eventviewer\api;..\..\..\..\..\libs\lowlevel\stm32hal\api;..\..\..\..\..\libs\highlevel\abslayer\hal2\api;..\..\..\..\..\libs\midware\hl-plus\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\embot\hw;..\bsp;..\..\..\..\..\embot\os;..\..\..\..\..\embot\app;..\src
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\eApplication-v6.sct
  link misc: --diag_suppress=L6329
  group main
    ../main/: embot_main.cpp
  group stm32hal.hal2
    ../../../../../libs/lowlevel/stm32hal/lib/: stm32hal.hal2.cpp
    ../../../../../libs/highlevel/abslayer/hal2/lib/: hal2.ems4rd.ethdbg.lib
    ../cfg/: hal_startup_stm32f407ig.s
  group rtos
    ../../../../../libs/highlevel/abslayer/osal/lib/: osal.cm4.dbg.lib
    ../../../../../libs/midware/eventviewer/src/: eventviewer.c
  group embot::core
    ../../../../../../../../../icub-firmware-shared/embot/core/: embot_core.cpp embot_core_binary.cpp embot_core_utils.cpp
  group embot::os
    ../../../../../embot/os/: embot_os.cpp embot_os_Action.cpp embot_os_rtos.cpp embot_os_theCallbackManager.cpp embot_os_theScheduler.cpp embot_os_theTimerManager.cpp embot_os_Thread.cpp embot_os_Timer.cpp
  group embot::hw-core
    ../../../../../embot/hw/: embot_hw.cpp embot_hw_sys.cpp embot_hw_bsp.cpp
  group embot::hw-extra
    ../../../../../embot/hw/: embot_hw_gpio.cpp embot_hw_led.cpp embot_hw_flash.cpp
  group embot::hw-over-hal2
    ../../../../../embot/hw/: embot_hw_over_hal2.cpp
  group embot::hw::bsp
    ../bsp/: embot_hw_bsp_ems.cpp
  group embot::app
    ../../../../../embot/app/: embot_app_theLEDmanager.cpp
  group test
    ../src/: test.cpp
target ems-stlink (6190000::V6.19::ARMCLANG)
  device: STM32F407IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: as above
  output: ems004 +hex
  AfterMake: cmd.exe /C copy .\Obj\ems004.hex ..\bin\ems.hex
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: as above
  c misc: -Wno-pragma-pack -Wno-deprecated-register -DxUSE_EMS4RD
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\eApplication-v6.sct
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 5.6.0
