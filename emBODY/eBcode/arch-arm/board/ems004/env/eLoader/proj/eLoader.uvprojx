# Keil uVision project eLoader.uvprojx, settings and files
target ems4 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: emsLoader +hex
  AfterMake: cmd.exe /C copy .\Obj\emsLoader.hex ..\bin\emsLoader.hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1
  c misc: -DBOARD_ems4
  c include: ..\..\..\..\..\libs\highlevel\services\embenv\api;..\..\cfg;..\..\..\..\..\libs\highlevel\abslayer\hal2\api;..\..\..\..\..\libs\highlevel\services\embodyrobot;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\icub;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core;..\..\..\..\..\..\..\..\..\icub-firmware-shared\can\canProtocolLib
  asm misc: --cpreproc
  asm include: ..\app
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\eLoader.sct
  group application
    ../../../../common/env/eLoader/: loader_updt.c
  group hal
    ../abslayer-cfg/: hal_core_cfg.h hal_core_cfg.c hal_startup_mpu_name_stm32f407ig.s
    ../../../../../libs/highlevel/abslayer/hal2/lib/: hal2.ems4rd.lib
  group arm-services-embenv
    ../../../../../libs/highlevel/services/embenv/src/: eEcommon.c eEsharedServices.c shalBASE.c shalINFO.c shalPART.c
target ems4-dbg (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: as above
  output: eLoader_ems004dbg +hex
  AfterMake: cmd.exe /C copy .\Obj\eLoader_ems004dbg.hex ..\bin\eLoader_ems004dbg.hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: HAL_IS_VERSION_2
  c misc: -DBOARD_ems4
  c include: as above
  asm misc: --cpreproc
  asm include: ..\app
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\eLoader.sct
software components: CMSIS:CORE 5.0.1
