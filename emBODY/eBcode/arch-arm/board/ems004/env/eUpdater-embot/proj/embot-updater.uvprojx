# Keil uVision project embot-updater.uvprojx, settings and files
target ems-osal (6140000::V6.14::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: emsUpdater +hex
  AfterMake: cmd.exe /C copy .\Obj\emsUpdater.hex ..\bin\emsUpdater.hex
  c flags: Optim=6 uC99=1 v6Lang=3 v6LangP=8 v6Lto=1 wLevel=3
  c define: EMBOBJ_USE_EMBOT BOARD_ems4 DONT_USE_IPADDR_FROM_IPAL_CFG_
  c misc: -Wno-pragma-pack -Wno-deprecated-register
  c include: ..\..\..\..\..\libs\highlevel\abslayer\ipal\api;..\..\..\..\..\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core;..\..\..\..\..\embobj\core\exec\multitask;..\..\..\..\..\embobj\plus\embenv;..\..\..\..\..\embobj\plus\ipnet;..\..\cfg;..\..\..\..\..\libs\highlevel\services\embenv\api;..\..\..\..\..\libs\midware\eventviewer\api;..\..\..\..\..\libs\highlevel\abslayer\hal2\api;..\..\..\..\..\libs\highlevel\services\embodyrobot;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\icub;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core;..\..\..\..\..\..\..\..\..\icub-firmware-shared\can\canProtocolLib;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\embot\os;..\..\..\..\..\embot\hw;..\..\..\..\common\env\eUpdater-embot;..\..\..\..\common\env\eUpdater-embot\stm32halfake
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\eUpdater-v6.sct
  link misc: --diag_suppress=L6329
  group app
    ../../../../common/env/eUpdater-embot/: main.cpp eupdater.c eupdater_parser.c eOcfg_sm_cangtw.c eupdater_cangtw.c eupdater-info.c updater-core.c
    ../../../../../../../../../icub-firmware-shared/eth/embobj/plus/comm-v2/icub/: EoUpdaterProtocol.c
  group abslayer
    ../../../../../libs/highlevel/abslayer/ipal/lib/: ipal.base.medium.cm4.lib
    ../../../../../libs/highlevel/abslayer/osal/lib/: osal.cm4.lib
    ../../../../../libs/highlevel/abslayer/hal2/lib/: hal2.ems4rd.lib
    ../../../../../libs/highlevel/abslayer/cmsisos2/lib/: cmsisos2.lib
  group cfg
    ../cfg/: hal_startup_mpu_name_stm32f407ig.s ipal_cfg.c ipal_cfg.h hal_core_cfg.c
  group eo-core
    ../../../../../../../../../icub-firmware-shared/eth/embobj/core/core/: EOaction.c EOarray.c EoCommon.c EOconstarray.c EOconstvector.c EOdeque.c EOfifo.c EOfifoByte.c EOfifoWord.c EOlist.c EOpacket.c EOsm.c EOtheErrorManager.c EOtheMemoryPool.c EOtimer.c EOumlsm.c EOvector.c EOVmutex.c EOVtask.c EOVtheCallbackManager.c EOVtheSystem.c EOVtheTimerManager.c
  group eo-mee-embot
    ../../../../../embobj/core/exec/multitask/embot/: EOMmutex.embot.cpp EOMtask.embot.cpp EOMtheCallbackManager.embot.cpp EOMtheSystem.embot.cpp EOMtheTimerManager.embot.cpp
  group eo-ipnet
    ../../../../../embobj/plus/ipnet/: EOMtheIPnet.c EOsocket.c EOsocketDatagram.c EOVtheIPnet.c
  group eo-arm-env
    ../../../../../embobj/plus/embenv/: EOtheARMenvironment.c EOVtheEnvironment.c
  group arm-services-embenv
    ../../../../../libs/highlevel/services/embenv/src/: eEcommon.c eEsharedServices.c shalBASE.c shalINFO.c shalPART.c
  group eventviewer
    ../../../../../libs/midware/eventviewer/src/: eventviewer.c
  group embot-core
    ../../../../../../../../../icub-firmware-shared/embot/core/: embot_core.cpp embot_core_binary.cpp embot_core_utils.cpp
  group embot-os
    ../../../../../embot/os/: embot_os.cpp embot_os_Action.cpp embot_os_rtos.cpp embot_os_theCallbackManager.cpp embot_os_theScheduler.cpp embot_os_theTimerManager.cpp embot_os_Thread.cpp embot_os_Timer.cpp
  group embot-hw
    ../../../../../embot/hw/: embot_hw.cpp
  group stm32hal
    ../../../../common/env/eUpdater-embot/stm32halfake/: stm32hal_fake.c
target ems-osal-zero (6140000::V6.14::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: as above
  output: emsUpdater +hex
  AfterMake: cmd.exe /C copy .\Obj\emsUpdater.hex ..\bin\emsUpdater.hex
  c flags: Optim=6 uC99=1 v6Lang=3 v6LangP=8 v6Lto=1 wLevel=3
  c define: USE_ZERO_OFFSET EMBOBJ_USE_EMBOT BOARD_ems4 DONT_USE_IPADDR_FROM_IPAL_CFG_
  c misc: -Wno-pragma-pack -Wno-deprecated-register
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\eUpdater-v6-zero.sct
  link misc: --diag_suppress=L6329
target ems-cmsisos2 (6140000::V6.14::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: as above
  output: emsUpdater +hex
  AfterMake: cmd.exe /C copy .\Obj\emsUpdater.hex ..\bin\emsUpdater.hex
  c flags: Optim=6 uC99=1 v6Lang=3 v6LangP=8 v6Lto=1 wLevel=3
  c define: EMBOT_USE_rtos_cmsisos2 EMBOBJ_USE_EMBOT BOARD_ems4 DONT_USE_IPADDR_FROM_IPAL_CFG_
  c misc: -Wno-pragma-pack -Wno-deprecated-register
  c include: ..\..\..\..\..\libs\highlevel\abslayer\ipal\api;..\..\..\..\..\libs\highlevel\abslayer\cmsisos2\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core;..\..\..\..\..\embobj\core\exec\multitask;..\..\..\..\..\embobj\plus\embenv;..\..\..\..\..\embobj\plus\ipnet;..\..\cfg;..\..\..\..\..\libs\highlevel\services\embenv\api;..\..\..\..\..\libs\midware\eventviewer\api;..\..\..\..\..\libs\highlevel\abslayer\hal2\api;..\..\..\..\..\libs\highlevel\services\embodyrobot;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\icub;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core;..\..\..\..\..\..\..\..\..\icub-firmware-shared\can\canProtocolLib;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\embot\os;..\..\..\..\..\embot\hw;..\..\..\..\common\env\eUpdater-embot;..\..\..\..\common\env\eUpdater-embot\stm32halfake
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\eUpdater-v6.sct
  link misc: --diag_suppress=L6329
target ems-cmsisos2-zero (6140000::V6.14::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: as above
  output: emsUpdater +hex
  AfterMake: cmd.exe /C copy .\Obj\emsUpdater.hex ..\bin\emsUpdater.hex
  c flags: Optim=6 uC99=1 v6Lang=3 v6LangP=8 v6Lto=1 wLevel=3
  c define: USE_ZERO_OFFSET EMBOT_USE_rtos_cmsisos2 EMBOBJ_USE_EMBOT BOARD_ems4 DONT_USE_IPADDR_FROM_IPAL_CFG_
  c misc: -Wno-pragma-pack -Wno-deprecated-register
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\eUpdater-v6.sct
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 5.4.0
