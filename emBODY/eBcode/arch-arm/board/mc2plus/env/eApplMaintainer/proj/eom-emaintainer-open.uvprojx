# Keil uVision project eom-emaintainer-open.uvprojx, settings and files
target mc2plus (6230000::V6.23::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: mc2plusApplPROGupdater +hex
  AfterMake: cmd.exe /C copy .\Obj\mc2plusApplPROGupdater.hex ..\bin\mc2plusApplPROGupdater.hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=8
  c define: _MAINTAINER_APPL_ DONT_USE_IPADDR_FROM_IPAL_CFG_
  c misc: -DBOARD_mc2plus -DEOMTASK_dont_register_thread_for_FATALERROR -Wno-pragma-pack -Wno-deprecated-register
  c include: ..\..\..\..\..\libs\highlevel\abslayer\ipal\api;..\..\..\..\..\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core;..\..\..\..\..\embobj\core\exec\multitask;..\..\..\..\..\embobj\plus\embenv;..\..\..\..\..\embobj\plus\ipnet;..\..\cfg;..\..\..\..\..\libs\highlevel\services\embenv\api;..\..\..\..\..\libs\midware\eventviewer\api;..\..\..\..\common\env\eMaintainer;..\..\..\..\..\libs\highlevel\abslayer\hal2\api;..\..\..\..\..\libs\highlevel\services\embodyrobot;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\icub;..\..\..\..\..\..\..\..\..\icub-firmware-shared\can\canProtocolLib
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\eApplication.sct
  group app-shared-with-updater
    ../../../../common/env/eUpdater/: eom-eupdater-main.c eupdater_parser.c updater-core.c
    ../../../../../../../../../icub-firmware-shared/eth/embobj/plus/comm-v2/icub/: EoUpdaterProtocol.c
  group app-only-for-maintainer
    ../../../../common/env/eMaintainer/: emaintainer-info.c
  group abslayer-lib
    ../../../../../libs/highlevel/abslayer/ipal/lib/: ipal.base.medium.cm4.lib
    ../../../../../libs/highlevel/abslayer/osal/lib/: osal.cm4.lib osal.cm4.dbg.lib
    ../../../../../libs/highlevel/abslayer/hal2/lib/: hal2.mc2plus.ethdbg.lib
  group abslayer-cfg
    ../abslayer-cfg/: hal_core_cfg.c ipal_cfg.c osal_cfg-open.c hal_core_cfg.h ipal_cfg.h osal_cfg-open.h hal_startup_mpu_name_stm32f407ig.s
  group eo-core
    ../../../../../../../../../icub-firmware-shared/eth/embobj/core/core/: EOtheLEDpulser.c EOaction.c EOarray.c EoCommon.c EOconstarray.c EOconstvector.c EOdeque.c EOfifo.c EOfifoByte.c EOfifoWord.c EOlist.c EOpacket.c EOsm.c EOtheErrorManager.c EOtheMemoryPool.c EOtimer.c EOumlsm.c EOvector.c EOVmutex.c EOVtask.c EOVtheCallbackManager.c EOVtheSystem.c EOVtheTimerManager.c
  group eo-mee
    ../../../../../embobj/core/exec/multitask/: EOMmutex.c EOMtask.c EOMtheCallbackManager.c EOMtheSystem.c EOMtheTimerManager.c
  group eo-ipnet
    ../../../../../embobj/plus/ipnet/: EOMtheIPnet.c EOsocket.c EOsocketDatagram.c EOVtheIPnet.c
  group eo-arm-env
    ../../../../../embobj/plus/embenv/: EOtheARMenvironment.c EOVtheEnvironment.c
  group arm-services-embenv
    ../../../../../libs/highlevel/services/embenv/src/: eEcommon.c eEsharedServices.c shalBASE.c shalINFO.c shalPART.c
  group eventviewer
    ../../../../../libs/midware/eventviewer/src/: eventviewer.c
software components: CMSIS:CORE 6.1.1
