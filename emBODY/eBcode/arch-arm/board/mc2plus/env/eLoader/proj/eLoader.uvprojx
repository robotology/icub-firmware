# Keil uVision project eLoader.uvprojx, settings and files
target mc2plus (6230000::V6.23::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: mc2plusLoader +hex
  AfterMake: cmd.exe /C copy .\Obj\mc2plusLoader.hex ..\bin\mc2plusLoader.hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=8
  c misc: -DBOARD_mc2plus -Wno-pragma-pack -Wno-deprecated-register
  c include: ..\..\..\..\..\libs\highlevel\services\embenv\api;..\..\cfg;..\..\..\..\..\libs\highlevel\abslayer\hal2\api;..\..\..\..\..\libs\highlevel\services\embodyrobot;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core;..\..\..\..\..\..\..\..\..\icub-firmware-shared\can\canProtocolLib;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\icub
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\eLoader.sct
  group application
    ../../../../common/env/eLoader/: loader_updt.c
  group hal
    ../abslayer-cfg/: hal_core_cfg.h hal_core_cfg.c hal_startup_mpu_name_stm32f407ig.s
    ../../../../../libs/highlevel/abslayer/hal2/lib/: hal2.mc2plus.ethdbg.lib
  group arm-services-embenv
    ../../../../../libs/highlevel/services/embenv/src/: eEcommon.c eEsharedServices.c shalBASE.c shalINFO.c shalPART.c
software components: CMSIS:CORE 6.1.1
