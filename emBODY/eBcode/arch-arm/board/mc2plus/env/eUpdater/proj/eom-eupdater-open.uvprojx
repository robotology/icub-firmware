# Keil uVision project eom-eupdater-open.uvprojx, settings and files
target mc4plus (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: eUpdaterCANgtw_mc4plus +hex
  AfterMake: cmd.exe /C copy .\Obj\eUpdaterCANgtw_mc4plus.hex ..\bin\eUpdaterCANgtw_mc4plus.hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1
  c define: DONT_USE_IPADDR_FROM_IPAL_CFG_
  c misc: -DemBODYrobot_ROBOT_NAME=iCubANY -DemBODYrobot_BOARD_NAME=boardMC4PLUS -DemBODYrobot_BOARD_NUMBER=boardnumberANY
  c include: ..\..\..\..\..\libs\highlevel\abslayer\ipal\api;..\..\..\..\..\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core;..\..\..\..\..\embobj\core\exec\multitask;..\..\..\..\..\embobj\plus\embenv;..\..\..\..\..\embobj\plus\ipnet;..\..\cfg;..\..\..\..\..\libs\highlevel\services\embenv\api;..\..\..\..\..\libs\midware\eventviewer\api;..\..\..\..\..\libs\highlevel\abslayer\hal2\api;..\..\..\..\..\libs\highlevel\services\embodyrobot
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\eUpdater.sct
  group app
    ../../../../common/env/eUpdater/: eom-eupdater-main.c eupdater_parser.c eOcfg_sm_cangtw.c eupdater_cangtw.c eupdater-info.c updater-core.c
  group abslayer-lib
    ../../../../../libs/highlevel/abslayer/ipal/lib/: ipal.base.medium.cm4.lib
    ../../../../../libs/highlevel/abslayer/osal/lib/: osal.cm4.lib osal.cm4.dbg.lib
    ../../../../../libs/highlevel/abslayer/hal2/lib/: hal2.mc4plus.ethdbg.lib
  group abslayer-cfg
    ../abslayer-cfg/: hal_core_cfg.h osal_cfg-open.h ipal_cfg.h ipal_cfg.c osal_cfg-open.c hal_core_cfg.c hal_startup_mpu_name_stm32f407ig.s
  group eo-core
    ../../../../../../../../../icub-firmware-shared/eth/embobj/core/core/: EOaction.c EOarray.c EoCommon.c EOconstarray.c EOconstvector.c EOdeque.c EOfifo.c EOfifoByte.c EOfifoWord.c EOlist.c EOpacket.c EOsm.c EOtheErrorManager.c EOtheMemoryPool.c EOtimer.c EOumlsm.c EOvector.c EOVmutex.c EOVtask.c EOVtheCallbackManager.c EOVtheSystem.c EOVtheTimerManager.c
  group eo-mee
    ../../../../../embobj/core/exec/multitask/: EOMmutex.c EOMtask.c EOMtheCallbackManager.c EOMtheSystem.c EOMtheTimerManager.c
  group eo-ipnet
    ../../../../../embobj/plus/ipnet/: EOMtheIPnet.c EOsocket.c EOsocketDatagram.c EOVtheIPnet.c
  group eo-arm-env
    ../../../../../embobj/plus/embenv/: EOtheARMenvironment.c EOVtheEnvironment.c
  group arm-services-embenv
    ../../../../../libs/highlevel/services/embenv/src/: eEcommon.c eEsharedServices.c shalBASE.c shalINFO.c shalPART.c
  group eventviewer
    ../../../../../libs/midware/eventviewer/src/: eventviewer.c
  group embody-robot
    ../../../../../libs/highlevel/services/embodyrobot/: emBODYrobot.c
target mc4plus-dbg (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.4.0
  cpu: as above
  output: eUpdaterCANgtw_mc4plusdbg +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: HAL_IS_VERSION_2 DONT_USE_IPADDR_FROM_IPAL_CFG_
  c misc: -DemBODYrobot_ROBOT_NAME=iCubANY -DemBODYrobot_BOARD_NAME=boardEMS4RD -DemBODYrobot_BOARD_NUMBER=boardnumberANY
  c include: ..\..\..\..\..\libs\highlevel\abslayer\ipal\api;..\..\..\..\..\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core;..\..\..\..\..\embobj\core\exec\multitask;..\..\..\..\..\embobj\plus\embenv;..\..\..\..\..\embobj\plus\ipnet;..\..\cfg;..\..\..\..\..\libs\highlevel\services\embenv\api;..\..\..\..\..\libs\highlevel\abslayer\hal2\api;..\..\..\..\..\libs\midware\eventviewer\api;..\..\..\..\..\libs\highlevel\services\embodyrobot
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\eUpdater.sct
software components: CMSIS:CORE 3.30.0
