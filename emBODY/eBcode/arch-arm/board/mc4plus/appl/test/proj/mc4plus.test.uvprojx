# Keil uVision project mc4plus.test.uvprojx, settings and files
target mc4plus-ulpro (6190000::V6.19::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: mc4plus +hex
  AfterMake: cmd.exe /C copy .\Obj\mc4plus.hex ..\bin\mc4plus.hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: USE_STM32HAL USE_hal2_DRIVER  STM32HAL_BOARD_MC4PLUS EMBOT_USE_rtos_osal
  c misc: -Wno-pragma-pack -Wno-deprecated-register
  c include: ..\..\..\..\..\libs\highlevel\abslayer\osal\api;..\cfg\abslayer;..\..\..\..\..\libs\midware\eventviewer\api;..\..\..\..\..\libs\lowlevel\stm32hal\api;..\..\..\..\..\libs\highlevel\abslayer\hal2\api;..\..\..\..\..\libs\midware\hl-plus\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\embot\hw;..\bsp;..\..\..\..\..\embot\os;..\..\..\..\..\embot\app;.;..\src
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\eApplication-v6.sct
  group main
    ../main/: embot_main.cpp
  group stm32hal.hal2
    ../../../../../libs/lowlevel/stm32hal/lib/: stm32hal.hal2.cpp
    ../../../../../libs/highlevel/abslayer/hal2/lib/: hal2.mc4plus.ethdbg.lib
    ../cfg/: hal_startup_mpu_name_stm32f407ig.s
  group rtos
    ../../../../../libs/midware/eventviewer/src/: eventviewer.c
    ../../../../../libs/highlevel/abslayer/osal/lib/: osal.cm4.dbg.lib
  group embot::core
    ../../../../../../../../../icub-firmware-shared/embot/core/: embot_core.cpp embot_core_binary.cpp embot_core_utils.cpp
  group embot::os
    ../../../../../embot/os/: embot_os.cpp embot_os_Action.cpp embot_os_rtos.cpp embot_os_theCallbackManager.cpp embot_os_theScheduler.cpp embot_os_theTimerManager.cpp embot_os_Thread.cpp embot_os_Timer.cpp
  group embot::hw-core
    ../../../../../embot/hw/: embot_hw.cpp embot_hw_sys.cpp embot_hw_bsp.cpp
  group embot::hw-others
    ../../../../../embot/hw/: embot_hw_gpio.cpp embot_hw_led.cpp
  group embot::hw-over-hal2
    ../../../../../embot/hw/: embot_hw_over_hal2.cpp
  group embot::hw::bsp
    ../bsp/: embot_hw_bsp_mc4plus.cpp
  group embot::app
    ../../../../../embot/app/: embot_app_theLEDmanager.cpp
  group test
    ../src/: test.cpp
target mc4plus-stlink (6190000::V6.19::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: as above
  output: mc4plus +hex
  AfterMake: cmd.exe /C copy .\Obj\mc4plus.hex ..\bin\mc4plus.hex
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: as above
  c misc: -Wno-pragma-pack -Wno-deprecated-register
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\eApplication-v6.sct
