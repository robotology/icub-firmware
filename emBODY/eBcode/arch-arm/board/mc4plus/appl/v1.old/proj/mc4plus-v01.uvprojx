# Keil uVision project mc4plus-v01.uvprojx, settings and files
target mc4plus (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: mc4plus +hex
  AfterMake: cmd.exe /C copy .\Obj\mc4plus.hex ..\bin\mc4plus.hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1
  c define: NOT_ICUB_GENOVA04 ICUB_DARMSTADT01 EOPROT_USE_MN_VERSION_2_0 HAL_IS_VERSION_2 USE_PROTO_PROXY
  c misc: -DemBODYrobot_ROBOT_NAME=iCubGenova04 -DemBODYrobot_BOARD_NAME=boardEMS4RD -DemBODYrobot_BOARD_NUMBER=boardnumberANY
  c include: ..\..\..\..\..\libs\highlevel\abslayer\ipal\api;..\..\..\..\..\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\exec\multitask;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\embenv;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\ipnet;..\..\..\..\..\libs\highlevel\services\embenv\api;..\..\..\..\..\libs\midware\eventviewer\api;..\cfg\eoemsappl;..\cfg\abslayer;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\ctrloop;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\icub;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\protocol\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\protocol\src;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\transport;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\board\ems001;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\mc;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\utils;.;..\cfg\eoprot-callbacks;..\src\eoappservices;..\cfg\eoappservices\icub-can-proto;..\cfg\eoappservices\icub-can-net;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\robotconfig\v1\backdoor;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\opcprot;..\..\..\..\..\..\..\..\..\icub-firmware-shared\can\canProtocolLib;..\cfg\eoprot-boards;..\..\..\..\..\libs\highlevel\abslayer\hal2\api;..\..\..\..\ems004\env\cfg;..\cfg\eoemsappl;..\..\..\..\..\libs\highlevel\services\embodyrobot;..\..\..\..\..\libs\midware\hl-plus\api
  asm misc: --cpreproc
  asm include: ..\cfg\abslayer
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\eApplication.sct
  group main
    ../main/: eom_emsappl_main.c
  group abslayer-lib
    ../../../../../libs/highlevel/abslayer/ipal/lib/: ipal.base.medium.cm4.lib
    ../../../../../libs/highlevel/abslayer/osal/lib/: osal.cm4.dbg.lib
    ../../../../../libs/highlevel/abslayer/hal2/lib/: hal2.mc4plus.ethdbg.lib
  group abslayer-cfg
    ../cfg/abslayer/: hal_core_cfg.h ipal_cfg.h osal_cfg.h hal_core_cfg.c ipal_cfg.c osal_cfg.c hal_startup_mpu_name_stm32f407ig.s
  group eo-core
    ../../../../../../../../../icub-firmware-shared/eth/embobj/core/core/: EOaction.c EOarray.c EoCommon.c EOconstarray.c EOconstvector.c EOdeque.c EOfifo.c EOfifoByte.c EOfifoWord.c EOlist.c EOpacket.c EOsm.c EOtheErrorManager.c EOtheLEDpulser.c EOtheMemoryPool.c EOtimer.c EOumlsm.c EOvector.c EOVmutex.c EOVtask.c EOVtheCallbackManager.c EOVtheSystem.c EOVtheTimerManager.c
  group eo-core-mee
    ../../../../../../../../../icub-firmware-shared/eth/embobj/core/exec/multitask/: EOMmutex.c EOMtask.c EOMtheCallbackManager.c EOMtheSystem.c EOMtheTimerManager.c
  group eo-ipnet
    ../../../../../../../../../icub-firmware-shared/eth/embobj/plus/ipnet/: EOMtheIPnet.c EOsocket.c EOsocketDatagram.c EOVtheIPnet.c
  group eo-arm-env
    ../../../../../../../../../icub-firmware-shared/eth/embobj/plus/embenv/: EOtheARMenvironment.c EOVtheEnvironment.c
  group eventviewer
    ../../../../../libs/midware/eventviewer/src/: eventviewer.c
  group arm-services-embenv
    ../../../../../libs/highlevel/services/embenv/src/: eEcommon.c eEsharedServices.c shalBASE.c shalINFO.c shalPART.c
  group eo-emsappl
    ../../../../../../../../../icub-firmware-shared/eth/embobj/plus/ctrloop/: eOcfg_sm_EMSappl.c EOMtheEMSappl.c EOMtheEMSapplCfg.c EOMtheEMSbackdoor.c EOMtheEMSbackdoortransceiver.c EOMtheEMSconfigurator.c EOMtheEMSdiscoverylistener.c EOMtheEMSdiscoverytransceiver.c EOMtheEMSerror.c EOMtheEMSrunner.c EOMtheEMSsocket.c EOMtheEMStransceiver.c
  group eo-emsappl-cfg
    ../cfg/eoemsappl/: EOMtheEMSapplCfg_cfg.h overridden_runner.c overridden_appl.c overridden_sm.c overridden_configurator.c overridden_backdoortransceiver.c overridden_error.c
  group opc-protocol
    ../../../../../../../../../icub-firmware-shared/eth/embobj/plus/comm-v2/opcprot/: OPCprotocolManager.c
  group opc-protocol-cfg
    ../../../../../../../../../icub-firmware-shared/eth/robotconfig/v1/backdoor/: OPCprotocolManager_Cfg.c
  group appl-services
    ../src/eoappservices/: EOtheEMSapplBody.c EOappCanServicesProvider.c EOappMeasuresConverter.c EOappTheDataBase.c EOtheProtocolWrapper.c EOappEncodersReader.c
  group appl-services-cfg
    ../cfg/eoappservices/icub-can-proto/: eOcfg_icubCanProto_messagesLookupTbl.c eOcfg_icubCanProto_motorBoardMsgFunctions.c eOcfg_icubCanProto_motorBoardMsgLookupTbl.c eOcfg_icubCanProto_sensorBoardMsgFunctions.c eOcfg_icubCanProto_sensorBoardMsgLookupTbl.c
    ../cfg/eoappservices/measures-converter/: measuresConvFuncOveridden.c
    ../cfg/eoappservices/icub-can-net/: eOcfg_appTheDataBase_ebx.c
  group eo-ems-can
    ../../../../../../../../../icub-firmware-shared/eth/embobj/plus/board/ems001/: EOicubCanProto.c
  group eo-motor-controller
    ../../../../../../../../../icub-firmware-shared/eth/embobj/plus/mc/: EOaxisController.c EOdecoupler.c EOemsController.c EOpid.c EOspeedmeter.c EOtrajectory.c
  group diagnostics
    ../../../../../../../../../icub-firmware-shared/eth/embobj/plus/board/ems001/: EOtheEMSapplDiagnostics.c
  group eo-comm-transport
    ../../../../../../../../../icub-firmware-shared/eth/embobj/plus/comm-v2/transport/: EOagent.c EOconfirmationManager.c EOhostTransceiver.c EOnvSet.c EOproxy.c EOnv.c EOreceiver.c EOrop.c EOropframe.c EOtheBOARDtransceiver.c EOtheFormer.c EOtheParser.c EOtransceiver.c EOtransmitter.c EOtheInfoDispatcher.c
  group eo-protocol
    ../../../../../../../../../icub-firmware-shared/eth/embobj/plus/comm-v2/protocol/src/: EoProtocol.c EoProtocolAS_fun.c EoProtocolAS_rom.c EoProtocolEPs.c EoProtocolMC_fun.c EoProtocolMC_rom.c EoProtocolMN_fun.c EoProtocolMN_rom.c EoProtocolSK_fun.c EoProtocolSK_rom.c
    ../../../../../../../../../icub-firmware-shared/eth/embobj/plus/comm-v2/icub/: EoError.c
  group eo-protocol-cfg-boards
    ../cfg/eoprot-boards/: eOprot_b01.c eOprot_b02.c eOprot_b03.c eOprot_b04.c eOprot_b05.c eOprot_b06.c eOprot_b07.c eOprot_b08.c eOprot_b09.c eOprot_b10.c eOprot_b11.c
  group eo-protocol-cfg-callbacks
    ../cfg/eoprot-callbacks/: EoProtocolMN_fun_ems4rd.c EoProtocolAS_fun_ems4rd.c EoProtocolSK_fun_ems4rd.c EoProtocolMC_fun_ems4rd.c
  group embody-robot
    ../../../../../libs/highlevel/services/embodyrobot/: emBODYrobot.c
target mc4plus-zero (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.2.0
  cpu: as above
  output: mc4plus-zero +hex
  AfterMake: cmd.exe /C copy .\Obj\mc4plus-zero.hex ..\bin\mc4plus-zero.hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: NOT_ICUB_GENOVA04 ICUB_DARMSTADT01 EOPROT_USE_MN_VERSION_2_0 HAL_IS_VERSION_2 USE_PROTO_PROXY EENV_EAPPLICATION_FORCE_CODE_OFFSET_TO_ZERO
  c misc: as above
  c include: as above
  asm misc: --cpreproc
  asm include: ..\cfg\abslayer
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\eApplication-zerooffset.sct
software components: CMSIS:CORE 3.30.0
