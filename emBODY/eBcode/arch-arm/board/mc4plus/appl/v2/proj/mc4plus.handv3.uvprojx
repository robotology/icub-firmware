# Keil uVision project mc4plus.handv3.uvprojx, settings and files
target mc4plus (6180000::V6.18::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: mc4plus +hex
  AfterMake: cmd.exe /C copy .\Obj\mc4plus.hex ..\bin\mc4plus.hex
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: DIAGNOSTIC2_enabled DIAGNOSTIC2_receive_from_daemon DIAGNOSTIC2_send_to_yarprobotinterface _noDIAGNOSTIC2_send_to_daemon FINGER_MK3
  c misc: -DxTESTRTC_IS_ACTIVE -DxEOTHESERVICES_customize_handV3_7joints -DEOTHESERVICES_customize_handV3 -Wno-pragma-pack -Wno-deprecated-register -DUSE_MC4PLUS -DUSE_OLD_BUGGY_MODE_TO_SEND_UP_FULLSCALE_WITH_INVERTED_BYTES
  c include: ..\..\..\..\..\libs\highlevel\abslayer\ipal\api;..\..\..\..\..\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core;..\..\..\..\..\libs\highlevel\services\embenv\api;..\cfg\boardcfg;..\cfg\eoemsappl;..\cfg\abslayer;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\icub;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\protocol\api;..\..\..\..\..\libs\midware\eventviewer\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\protocol\src;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\transport;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\utils;.;..\src\eoappservices;..\cfg\eoappservices\icub-can-proto;..\cfg\eoappservices\icub-can-net;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\robotconfig\v1\backdoor;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\opcprot;..\..\..\..\..\..\..\..\..\icub-firmware-shared\can\canProtocolLib;..\..\..\..\..\libs\highlevel\abslayer\hal2\api;..\..\..\..\ems004\env\cfg;..\..\..\..\..\libs\highlevel\services\embodyrobot;..\..\..\..\..\libs\midware\hl-plus\api;..\..\..\..\..\embobj\core\exec\multitask;..\..\..\..\..\embobj\plus\ctrloop;..\..\..\..\..\embobj\plus\embenv;..\..\..\..\..\embobj\plus\ipnet;..\..\..\..\..\embobj\plus\board;..\..\..\..\..\embobj\plus\can;..\..\..\..\..\embobj\plus\can\config-can-protocol;..\..\..\..\..\embobj\plus\mc;..\..\..\..\ems004\appl\v2\cfg\eoprot-callbacks;..\..\..\..\ems004\appl\v2\src\eoappservices;..\..\..\..\..\embot\cif;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\prot\eth
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\eApplication-v6.sct
  group main
    ../main/: eom_emsappl_main.cpp
  group abslayer-lib
    ../../../../../libs/highlevel/abslayer/ipal/lib/: ipal.base.medium.cm4.lib
    ../../../../../libs/highlevel/abslayer/osal/lib/: osal.cm4.lib
    ../../../../../libs/highlevel/abslayer/hal2/lib/: hal2.mc4plus.ethdbg.lib
  group abslayer-cfg
    ../cfg/abslayer/: hal_core_cfg.h ipal_cfg.h osal_cfg.h hal_core_cfg.c ipal_cfg.c osal_cfg.c hal_startup_mpu_name_stm32f407ig-v6.s
  group eo-core
    ../../../../../../../../../icub-firmware-shared/eth/embobj/core/core/: EOaction.c EOarray.c EoCommon.c EOconstarray.c EOconstvector.c EOdeque.c EOfifo.c EOfifoByte.c EOfifoWord.c EOlist.c EOpacket.c EOsm.c EOtheErrorManager.c EOtheLEDpulser.c EOtheMemoryPool.c EOtimer.c EOumlsm.c EOvector.c EOVmutex.c EOVtask.c EOVtheCallbackManager.c EOVtheSystem.c EOVtheTimerManager.c
  group eo-core-mee
    ../../../../../embobj/core/exec/multitask/: EOMmutex.c EOMtask.c EOMtheCallbackManager.c EOMtheSystem.c EOMtheTimerManager.c
  group eo-ipnet
    ../../../../../embobj/plus/ipnet/: EOMtheIPnet.c EOsocket.c EOsocketDatagram.c EOVtheIPnet.c
  group eo-arm-env
    ../../../../../embobj/plus/embenv/: EOtheARMenvironment.c EOVtheEnvironment.c
  group eventviewer
    ../../../../../libs/midware/eventviewer/src/: eventviewer.c
  group arm-services-embenv
    ../../../../../libs/highlevel/services/embenv/src/: eEcommon.c eEsharedServices.c shalBASE.c shalINFO.c shalPART.c
  group eo-emsappl
    ../../../../../embobj/plus/ctrloop/: eOcfg_sm_EMSappl.c EOMtheEMSappl.c EOMtheEMSapplCfg.c EOMtheEMSconfigurator.c EOMtheEMSdiscoverylistener.c EOMtheEMSdiscoverytransceiver.c EOMtheEMSerror.c EOMtheEMSrunner.c EOMtheEMSsocket.c EOMtheEMStransceiver.c EOMtheEMSbackdoor.c EOMtheEMSbackdoortransceiver.c
    ../../../../../../../../../icub-firmware-shared/eth/embobj/plus/comm-v2/opcprot/: OPCprotocolManager.c
  group eo-emsappl-cfg
    ../cfg/eoemsappl/: EOMtheEMSapplCfg_cfg.h overridden_runner.c overridden_appl.c overridden_sm.c overridden_configurator.c overridden_backdoortransceiver.c overridden_error.c overridden_controller.c
    ../../../../ems004/appl/v2/src/eoappservices/: testRTC.c
  group appl-services
    ../../../../../embobj/plus/ctrloop/: EOMtheEMSdiagnostic.cpp
    ../../../../../embobj/plus/board/: EOtheEntities.c EOappEncodersReader.c
    ../../../../ems004/appl/v2/src/eoappservices/: EOtheCANdiscovery2.c EOtheMAIS.c EOCurrentsWatchdog.c EOtheSKIN.c EOtheInertials2.c EOtheServices.c EOtheMotionController.c EOtheEncoderReader.c EOtheETHmonitor.c EOtheSTRAIN.c EOtheMC4boards.c EOtheVirtualStrain.c EOwatchdog.c EOtheMEMS.c EOtheSharedHW.c EOtheInertials3.c EOtheTemperatures.c EOthePSC.c EOthePOS.c EOtheFatalError.c embot_app_eth_CANmonitor.cpp embot_app_eth_theFTservice.cpp embot_app_eth_theBATservice.cpp
  group eo-motor-controller
    ../../../../../embobj/plus/mc/: Calibrators.c AbsEncoder.c Controller.c Joint.c JointSet.c Motor.c Pid.c Trajectory.c WatchDog.c
  group eo-comm-transport
    ../../../../../../../../../icub-firmware-shared/eth/embobj/plus/comm-v2/transport/: EOagent.c EOconfirmationManager.c EOhostTransceiver.c EOnvSet.c EOproxy.c EOnv.c EOreceiver.c EOrop.c EOropframe.c EOtheBOARDtransceiver.c EOtheFormer.c EOtheParser.c EOtransceiver.c EOtransmitter.c EOtheInfoDispatcher.c
  group eo-protocol
    ../../../../../../../../../icub-firmware-shared/eth/embobj/plus/comm-v2/protocol/src/: EoProtocol.c EoProtocolAS_fun.c EoProtocolAS_rom.c EoProtocolEPs.c EoProtocolMC_fun.c EoProtocolMC_rom.c EoProtocolMN_fun.c EoProtocolMN_rom.c EoProtocolSK_fun.c EoProtocolSK_rom.c
    ../../../../../../../../../icub-firmware-shared/eth/embobj/plus/comm-v2/icub/: EoError.c EoAnalogSensors.c EoBoards.c EoManagement.c EoUpdaterProtocol.c EoMotionControl.c
  group eo-protocol-cfg-callbacks
    ../../../../ems004/appl/v2/cfg/eoprot-callbacks/: EoProtocolMN_fun_ems4rd.c EoProtocolAS_fun_ems4rd.c EoProtocolMC_fun_ems4rd.c EoProtocolSK_fun_ems4rd.c
  group eoprot-can
    ../../../../../embobj/plus/can/: EOtheCANmapping.c EOtheCANprotocol.c EOtheCANservice.c
  group eoprot-can-cfg-protocol
    ../../../../../embobj/plus/can/config-can-protocol/: EoCANprotMCpolling.c EoCANprotMCperiodic.c EoCANprotASperiodic.c EoCANprotASpolling.c EoCANprotSKperiodic.c EoCANprotISperiodic.c EoCANprotBSperiodic.c
  group embot::prot::core
    ../../../../../embot/cif/: embot_cif_core.cpp
    ../../../../../../../../../icub-firmware-shared/embot/core/: embot_core.cpp embot_core_binary.cpp embot_core_utils.cpp
  group embot::prot::eth
    ../../../../../embot/cif/: embot_cif_diagnostic.cpp
    ../../../../../../../../../icub-firmware-shared/embot/prot/eth/: embot_prot_eth_diagnostic_Host.cpp embot_prot_eth_diagnostic_Node.cpp embot_prot_eth_rop.cpp embot_prot_eth_ropframe.cpp
target mc4plus-zero (ARM-ADS)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: as above
  output: mc4plus-zero +hex
  AfterMake: cmd.exe /C copy .\Obj\mc4plus-zero.hex ..\bin\mc4plus-zero.hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NOT_ICUB_GENOVA04 ICUB_DARMSTADT01 USE_PROTO_PROXY
  c misc: -DUSE_MC4PLUS
  c include: ..\..\..\..\..\libs\highlevel\abslayer\ipal\api;..\..\..\..\..\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\exec\multitask;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\embenv;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\ipnet;..\..\..\..\..\libs\highlevel\services\embenv\api;..\..\..\..\..\libs\midware\eventviewer\api;..\cfg\eoemsappl;..\cfg\abslayer;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\ctrloop;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\icub;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\protocol\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\protocol\src;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\transport;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\board\ems001;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\utils;.;..\cfg\eoprot-callbacks;..\src\eoappservices;..\cfg\eoappservices\icub-can-proto;..\cfg\eoappservices\icub-can-net;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\robotconfig\v1\backdoor;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\opcprot;..\..\..\..\..\..\..\..\..\icub-firmware-shared\can\canProtocolLib;..\cfg\eoprot-boards;..\..\..\..\..\libs\highlevel\abslayer\hal2\api;..\..\..\..\ems004\env\cfg;..\cfg\eoemsappl;..\..\..\..\..\libs\highlevel\services\embodyrobot;..\..\..\..\..\libs\midware\hl-plus\api;..\src\eoappservices\mc
  asm misc: --cpreproc
  asm include: ..\cfg\abslayer
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\eApplication-zerooffset.sct
