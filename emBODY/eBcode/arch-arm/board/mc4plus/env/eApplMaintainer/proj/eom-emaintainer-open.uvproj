# Keil uVision project eom-emaintainer-open.uvproj, settings and files
target mcbstm32f400 (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: eomeupdater-updt +hex
  c flags: Optim=1 OneElfS=1
  c define: HAL_USE_ARCH_ARM _MAINTAINER_APPL_ HAL_USE_VERSION_2
  c misc: --c99
  c include: ..\..\..\..\..\libs\highlevel\abslayer\ipal\api;..\..\..\..\..\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\embobj\core\core;..\..\..\..\..\..\embobj\core\exec\multitask;..\..\..\..\..\..\embobj\plus\embenv;..\..\..\..\..\..\embobj\plus\ipnet;..\..\cfg;..\..\..\..\..\libs\highlevel\services\embenv\api;..\..\..\..\..\libs\highlevel\abslayer\hal2\api;..\..\..\..\..\libs\midware\eventviewer\api;..\..\..\..\ems001\env\eApplMaintainer\app
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\eApplication.sct
  group app-shared-with-updater
    ../../../../ems001/env/eUpdater/app/: eom-eupdater-main.c eupdater_parser.c updater-core.c
  group app-only-for-maintainer
    ../../../../ems001/env/eApplMaintainer/app/: emaintainer-info.c
  group abslayer-lib
    ../../../../../libs/highlevel/abslayer/ipal/lib/: ipal.base.medium.cm4.lib
    ../../../../../libs/highlevel/abslayer/osal/lib/: osal.cm4.lib osal.cm4.dbg.lib
    ../../../../../libs/highlevel/abslayer/hal2/lib/: hal2.ems4rd.lib
  group abslayer-cfg
    ../abslayer-cfg/: hal_core_cfg.c ipal_cfg.c osal_cfg-open.c hal_core_cfg.h ipal_cfg.h osal_cfg-open.h hal_startup_mpu_name_stm32f407ig.s
  group eo-core
    ../../../../../../embobj/core/core/: EOtheLEDpulser.c EOaction.c EOarray.c EoCommon.c EOconstarray.c EOconstvector.c EOdeque.c EOfifo.c EOfifoByte.c EOfifoWord.c EOlist.c EOpacket.c EOsm.c EOtheErrorManager.c EOtheMemoryPool.c EOtimer.c EOumlsm.c EOvector.c EOVmutex.c EOVtask.c EOVtheCallbackManager.c EOVtheSystem.c EOVtheTimerManager.c
  group eo-mee
    ../../../../../../embobj/core/exec/multitask/: EOMmutex.c EOMtask.c EOMtheCallbackManager.c EOMtheSystem.c EOMtheTimerManager.c
  group eo-ipnet
    ../../../../../../embobj/plus/ipnet/: EOMtheIPnet.c EOsocket.c EOsocketDatagram.c EOVtheIPnet.c
  group eo-arm-env
    ../../../../../../embobj/plus/embenv/: EOtheARMenvironment.c EOVtheEnvironment.c
  group arm-services-embenv
    ../../../../../libs/highlevel/services/embenv/src/: eEcommon.c eEsharedServices.c shalBASE.c shalINFO.c shalPART.c
  group eventviewer
    ../../../../../libs/midware/eventviewer/src/: eventviewer.c
target ems004 (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: as above
  output: eMaintainer_ems004_open +hex
  AfterMake: cmd.exe /C copy .\Obj\eMaintainer_ems004_open.hex ..\bin\eMaintainer_ems004_open.hex
  c flags: Optim=4 oTime=1 OneElfS=1
  c define: HAL_USE_ARCH_ARM BOARD_EMS004 _MAINTAINER_APPL_ HAL_USE_VERSION_2 DONT_USE_IPADDR_FROM_IPAL_CFG_
  c misc: --c99
  c include: ..\..\..\..\..\libs\highlevel\abslayer\ipal\api;..\..\..\..\..\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\embobj\core\core;..\..\..\..\..\..\embobj\core\exec\multitask;..\..\..\..\..\..\embobj\plus\embenv;..\..\..\..\..\..\embobj\plus\ipnet;..\..\cfg;..\..\..\..\..\libs\highlevel\services\embenv\api;..\..\..\..\..\libs\midware\eventviewer\api;..\..\..\..\ems001\env\eApplMaintainer\app;..\..\..\..\..\libs\highlevel\abslayer\hal2\api
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\eApplication.sct
target ems004-dbg (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: as above
  output: eMaintainer_ems004_open +hex
  AfterMake: as above
  c flags: Optim=1 OneElfS=1
  c define: as above
  c misc: --c99
  c include: as above
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\eApplication.sct
