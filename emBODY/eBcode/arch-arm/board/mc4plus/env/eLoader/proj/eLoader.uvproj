# Keil uVision project eLoader.uvproj, settings and files
target mcbstm32f400 (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: eLoader-updt +hex
  c flags: Optim=1 OneElfS=1
  c define: HAL_BOARD_MCBSTM32F400 BOARD_MCBSTM32F400
  c misc: --c99
  c include: ..\..\..\..\..\libs\highlevel\services\embenv\api;..\..\cfg;..\..\..\..\..\..\..\eBtest\arch-arm\libs\highlevel\abslayer\hal2\hal\hal-api
  asm misc: --cpreproc
  asm include: ..\app
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\eLoader.sct
  group application
    ../../../../ems001/env/eLoader/app/: loader_updt.c
  group hal
    ../abslayer-cfg/: hal_core_cfg.h hal_core_cfg.c hal_startup_mpu_name_stm32f407ig.s
    ../../../../../libs/highlevel/abslayer/hal2/lib/: hal2.ems4rd.lib
  group arm-services-embenv
    ../../../../../libs/highlevel/services/embenv/src/: eEcommon.c eEsharedServices.c shalBASE.c shalINFO.c shalPART.c
target ems004 (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: as above
  output: eLoader_ems004 +hex
  AfterMake: cmd.exe /C copy .\Obj\eLoader_ems004.hex ..\bin\eLoader_ems004.hex
  c flags: Optim=4 oTime=1 OneElfS=1
  c define: HAL_BOARD_EMS004 BOARD_EMS004 HAL_IS_VERSION_2
  c misc: --c99
  c include: ..\..\..\..\..\libs\highlevel\services\embenv\api;..\..\cfg;..\..\..\..\..\libs\highlevel\abslayer\hal2\api
  asm misc: --cpreproc
  asm include: ..\app
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\eLoader.sct
target ems004-dbg (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: as above
  output: eLoader_ems004 +hex
  AfterMake: as above
  c flags: Optim=1 OneElfS=1
  c define: HAL_BOARD_EMS004 BOARD_EMS004 HAL_IS_VERSION_2
  c misc: --c99
  c include: as above
  asm misc: --cpreproc
  asm include: ..\app
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\eLoader.sct
