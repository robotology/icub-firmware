# Keil uVision project eLoader.uvprojx, settings and files
target mc4plus (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: eLoader_mc4plus +hex
  AfterMake: cmd.exe /C copy .\Obj\eLoader_mc4plus.hex ..\bin\eLoader_mc4plus.hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1
  c define: HAL_IS_VERSION_2
  c misc: -DemBODYrobot_ROBOT_NAME=iCubANY -DemBODYrobot_BOARD_NAME=boardEMS4RD -DemBODYrobot_BOARD_NUMBER=boardnumberANY
  c include: ..\..\..\..\..\libs\highlevel\services\embenv\api;..\..\cfg;..\..\..\..\..\libs\highlevel\abslayer\hal2\api;..\..\..\..\..\libs\highlevel\services\embodyrobot
  asm misc: --cpreproc
  asm include: ..\app
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\eLoader.sct
  group application
    ../../../../common/env/eLoader/: loader_updt.c
  group hal
    ../abslayer-cfg/: hal_core_cfg.h hal_core_cfg.c hal_startup_mpu_name_stm32f407ig.s
    ../../../../../libs/highlevel/abslayer/hal2/lib/: hal2.mc4plus.ethdbg.lib
  group arm-services-embenv
    ../../../../../libs/highlevel/services/embenv/src/: eEcommon.c eEsharedServices.c shalBASE.c shalINFO.c shalPART.c
  group embody-robot
    ../../../../../libs/highlevel/services/embodyrobot/: emBODYrobot.c
target mc4plus-dbg (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: as above
  output: eLoader_mc4plusdbg +hex
  AfterMake: cmd.exe /C copy .\Obj\eLoader_mc4plusdbg.hex ..\bin\eLoader_mc4plusdbg.hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: HAL_IS_VERSION_2
  c misc: as above
  c include: as above
  asm misc: --cpreproc
  asm include: ..\app
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\eLoader.sct
software components: CMSIS:CORE 3.30.0
