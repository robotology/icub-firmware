# Keil uVision project erase-eeprom.uvprojx, settings and files
target mc4plus (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: eraseEEPROM +hex
  AfterMake: cmd.exe /C copy .\obj\eraseEEPROM.hex ..\bin\eraseEEPROM.hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: HAL_USE_LIB
  c include: ..\..\..\..\..\libs\highlevel\abslayer\hal2\api
  asm misc: --cpreproc
  asm include: ..\hal-cfg
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ../../../../common/env/eraseEEPROM/: eepromErase.c
  group hal-cfg
    ../abslayer-cfg/: hal_core_cfg.c hal_core_cfg.h
  group hal-startup
    ../abslayer-cfg/: hal_startup_mpu_name_stm32f407ig.s
  group hal2
    ../../../../../libs/highlevel/abslayer/hal2/lib/: hal2.mc4plus.ethdbg.lib
software components: CMSIS:CORE 5.0.1
