# Keil uVision project mtb4-bootloader.uvprojx, settings and files
target nucleo-btl (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: nucleo-hal
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: STM32HAL_BOARD_NUCLEO64
  c misc: --cpp11
  c include: ..\src-plus;..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\eBcode\arch-arm\libs\midware\eventviewer\api;..\..\..\..\..\..\eBcode\arch-arm\embobj\core\exec\multitask;..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core;..\..\..\..\..\..\eBcode\arch-arm\libs\lowlevel\stm32hal\api;..\..\..\..\..\..\eBcode\arch-arm\embot\common;..\..\..\..\..\..\eBcode\arch-arm\embot\app;..\..\..\..\..\..\eBcode\arch-arm\embot\i2h;..\..\..\..\..\..\eBcode\arch-arm\embot\hw;..\..\..\..\..\..\eBcode\arch-arm\embot\sys;..\..\..\..\..\..\eBcode\arch-arm\embot
  asm misc: --cpreproc
  asm include: ..\cfg
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000020 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: .\nucleo-bootloader.sct
  link misc: --diag_suppress=L6329
  group main
    ../src/: main-bootloader.cpp
  group stm32hal-nucleo
    ../../../../../../eBcode/arch-arm/libs/lowlevel/stm32hal/lib/: stm32hal.mtb4.lib
    ../../../../../../eBcode/arch-arm/libs/lowlevel/stm32hal/startup/: stm32hal.startup.mtb4.s
  group stm32hal-config
    ../cfg/: stm32hal_stg.h
  group osal
    ../../../../../../eBcode/arch-arm/libs/highlevel/abslayer/osal/lib/: osal.cm4.dbg.lib
  group eventviewer
    ../../../../../../eBcode/arch-arm/libs/midware/eventviewer/src/: eventviewer.c
  group embobj-shared
    ../../../../../../../../icub-firmware-shared/eth/embobj/core/core/: EOaction.c EOarray.c EoCommon.c EOconstarray.c EOconstvector.c EOdeque.c EOfifo.c EOfifoByte.c EOfifoWord.c EOlist.c EOpacket.c EOsm.c EOtheErrorManager.c EOtheLEDpulser.c EOtheMemoryPool.c EOtimer.c EOumlsm.c EOvector.c EOVmutex.c EOVtask.c EOVtheCallbackManager.c EOVtheSystem.c EOVtheTimerManager.c
  group embobj-mee
    ../../../../../../eBcode/arch-arm/embobj/core/exec/multitask/: EOMtheTimerManager.c EOMtheCallbackManager.c EOMtask.c EOMmutex.c
  group embot
    ../../../../../../eBcode/arch-arm/embot/binary/: embot_binary.cpp
    ../../../../../../eBcode/arch-arm/embot/common/: embot_common.cpp
    ../../../../../../eBcode/arch-arm/embot/app/: embot_app_theBootloader.cpp embot_app_theCANboardInfo.cpp embot_app_bootloader_theCANparser.cpp embot_app_canprotocol.cpp embot_app_canprotocol_bootloader.cpp
    ../../../../../../eBcode/arch-arm/embot/i2h/: embot_i2h.cpp
    ../../../../../../eBcode/arch-arm/embot/sys/: embot_sys.cpp embot_sys_Task.cpp embot_sys_theCallbackManager.cpp embot_sys_theJumper.cpp embot_sys_theScheduler.cpp embot_sys_theStorage.cpp embot_sys_theTimerManager.cpp embot_sys_Timer.cpp slim_retarget_io.c
  group embot-hw
    ../../../../../../eBcode/arch-arm/embot/hw/: embot_hw_FlashBurner.cpp embot_hw_FlashStorage.cpp embot_hw_can.cpp embot_hw_sys.cpp embot_hw_flash.cpp embot_hw_led.cpp embot_hw_bsp.cpp embot_hw.cpp
target mtb4-btl-ulpro (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L433RCIx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: mtb4_bootloader +hex
  AfterMake: cmd.exe /C copy .\Obj\mtb4_bootloader.hex ..\bin\mtb4.bootloader.hex
  c flags: Optim=4 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32HAL_BOARD_MTB4  STM32HAL_HAS_CAN_API_V183
  c misc: --cpp11
  c include: ..\src-plus;..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\eBcode\arch-arm\libs\midware\eventviewer\api;..\..\..\..\..\..\eBcode\arch-arm\embobj\core\exec\multitask;..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core;..\..\..\..\..\..\eBcode\arch-arm\libs\lowlevel\stm32hal\api;..\..\..\..\..\..\eBcode\arch-arm\embot\common;..\..\..\..\..\..\eBcode\arch-arm\embot\app;..\..\..\..\..\..\eBcode\arch-arm\embot\i2h;..\..\..\..\..\..\eBcode\arch-arm\embot\hw;..\..\..\..\..\..\eBcode\arch-arm\embot\sys;..\..\..\..\..\..\eBcode\arch-arm\embot;..\..\..\..\..\..\eBcode\arch-arm\embot\binary;..\..\..\..\..\..\..\..\icub-firmware-shared\can\canProtocolLib
  asm misc: --cpreproc
  asm include: ..\cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\mtb4-bootloader.sct
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 5.0.1
