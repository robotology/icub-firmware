# Keil uVision project mtb4-stm32app.uvprojx, settings and files
target mtb-stm32app (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L433RCIx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: nucleo-hal
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32HAL_BOARD_MTB4
  c misc: --cpp11
  c include: ..\..\..\..\..\..\..\eBcode\arch-arm\libs\lowlevel\stm32hal\api
  asm misc: --cpreproc
  asm include: ..\cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\mtb4-application0offset.sct
  link misc: --diag_suppress=L6329
  group mbt4-app
    ../src/: main-application.cpp
  group stm32hal-mtb4
    ../../../../../../../eBcode/arch-arm/libs/lowlevel/stm32hal/lib/: stm32hal.mtb4.lib
    ../../../../../../../eBcode/arch-arm/libs/lowlevel/stm32hal/startup/: stm32hal.startup.mtb4.s
  group stm32hal-config
    ../cfg/: stm32hal_stg.h
software components: CMSIS:CORE 5.0.1
