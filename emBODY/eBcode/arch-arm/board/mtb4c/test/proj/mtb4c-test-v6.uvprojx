# Keil uVision project mtb4c-test-v6.uvprojx, settings and files
target mtb4c-test-v190 (6190000::V6.19::ARMCLANG)
  device: STM32L452RCIx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: mtb4_revC_test_v190 +hex
  AfterMake: cmd.exe /C copy .\Obj\mtb4_revC_test_v190.hex ..\bin\mtb4_revC_test_v190.hex
  c flags: Optim=6 oTime=1 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_MTB4C STM32HAL_DRIVER_V190
  c misc: -Wno-pragma-pack -Wno-deprecated-register
  c include: ..\src-plus;..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\eBcode\arch-arm\libs\midware\eventviewer\api;..\..\..\..\..\..\eBcode\arch-arm\libs\lowlevel\stm32hal\api;..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\..\eBcode\arch-arm\embot\app;..\..\..\..\..\..\eBcode\arch-arm\embot\i2h;..\..\..\..\..\..\eBcode\arch-arm\embot\hw;..\..\..\..\..\..\eBcode\arch-arm\embot\os;..\..\..\..\..\..\eBcode\arch-arm\embot;..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\..\..\..\icub-firmware-shared\can\canProtocolLib;..\..\..\..\embot\app\skeleton;..\..\..\..\embot\prot\can;..\..\bsp
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: .\mt4c-test-v6.sct
  link misc: --diag_suppress=L6329
  group main
    ../src/: main-test.cpp embot_code_bootloader-for-test.cpp
  group stm32hal
    ../../../../libs/lowlevel/stm32hal/lib/: stm32hal.l4.v190.mtb4c.lib
  group stm32hal-config
    ../cfg/: stm32hal.startup.mtb4c.s
  group rtos
    ../../../../libs/highlevel/abslayer/cmsisos2/lib/: cmsisos2.lib
    ../../../../../../eBcode/arch-arm/libs/highlevel/abslayer/osal/lib/: osal.cm4.dbg.lib
    ../../../../../../eBcode/arch-arm/libs/midware/eventviewer/src/: eventviewer.c
  group embot
    ../../../../../../../../icub-firmware-shared/embot/core/: embot_core_binary.cpp embot_core.cpp
    ../../../../../../eBcode/arch-arm/embot/app/: embot_app_theBootloader.cpp embot_app_theCANboardInfo.cpp embot_app_theJumper.cpp embot_app_bootloader_theCANparser.cpp
    ../../../../../../eBcode/arch-arm/embot/os/: embot_os.cpp embot_os_Thread.cpp embot_os_theCallbackManager.cpp embot_os_theScheduler.cpp embot_os_theTimerManager.cpp embot_os_Timer.cpp
    ../../../../../../eBcode/arch-arm/embot/prot/can/: embot_prot_can.cpp embot_prot_can_bootloader.cpp
    ../../../../embot/os/: embot_os_Action.cpp embot_os_rtos.cpp
    ../../../../embot/app/: embot_app_theLEDmanager.cpp
  group embot-hw
    ../../../../embot/hw/: embot_hw_timer.cpp embot_hw_gpio.cpp embot_hw_si7051.cpp embot_hw_i2c.cpp embot_hw_bno055.cpp
    ../../../../../../eBcode/arch-arm/embot/hw/: embot_hw_FlashBurner.cpp embot_hw_FlashStorage.cpp embot_hw_can.cpp embot_hw_sys.cpp embot_hw_flash.cpp embot_hw_led.cpp embot_hw_bsp.cpp embot_hw.cpp
  group embot-hw-lowlevel
    ../../../../embot/hw/: embot_hw_lowlevel.cpp
  group embot::hw::bsp
    ../../bsp/: embot_hw_bsp_mtb4c.cpp
software components: CMSIS:CORE 5.6.0
