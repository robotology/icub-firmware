# Keil uVision project mtb4fap-appfap.uvprojx, settings and files
target mtb4fap-mtb4 (6180000::V6.18::ARMCLANG)
  device: STM32L433RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00004000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: mtb4fap +hex
  AfterMake: cmd.exe /C copy .\Obj\mtb4_v190.hex ..\bin\mtb4.v190.hex
  c flags: Optim=6 oTime=1 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_MTB4 STM32HAL_DRIVER_V190
  c misc: -Wno-pragma-pack -Wno-deprecated-register
  c include: ..\src-plus;..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\eBcode\arch-arm\libs\midware\eventviewer\api;..\..\..\..\..\..\eBcode\arch-arm\embobj\core\exec\multitask;..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core;..\..\..\..\..\..\eBcode\arch-arm\libs\lowlevel\stm32hal\api;..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\..\eBcode\arch-arm\embot\app;..\..\..\..\..\..\eBcode\arch-arm\embot\i2h;..\..\..\..\..\..\eBcode\arch-arm\embot\hw;..\..\..\..\..\..\eBcode\arch-arm\embot\os;..\..\..\..\..\..\eBcode\arch-arm\embot;..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\..\..\..\icub-firmware-shared\can\canProtocolLib;..\..\..\..\embot\app\skeleton;..\..\..\..\embot\prot\can;..\bsp
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x4000
  scatter file: .\mtb4fap-appfap.sct
  link misc: --diag_suppress=L6329
  group main
    ../src/: mtb4fap-appfap.cpp
    ../../../../embot/app/skeleton/: embot_app_skeleton_os_basic.cpp embot_app_skeleton_os_evthreadcan.cpp
  group stm32hal
    ../../../../libs/lowlevel/stm32hal/lib/: stm32hal.mtb4.v190.lib stm32hal.mtb4fap.v1D3.lib
  group stm32hal-config
    ../cfg/: stm32hal.startup.mtb4.s stm32hal.startup.mtb4fap.s
  group rtos
    ../../../../libs/highlevel/abslayer/cmsisos2/lib/: cmsisos2.lib
    ../../../../../../eBcode/arch-arm/libs/highlevel/abslayer/osal/lib/: osal.cm4.dbg.lib
    ../../../../../../eBcode/arch-arm/libs/midware/eventviewer/src/: eventviewer.c
  group embot-core
    ../../../../../../eBcode/arch-arm/embot/os/: embot_os.cpp embot_os_Thread.cpp embot_os_theCallbackManager.cpp embot_os_theScheduler.cpp embot_os_theTimerManager.cpp embot_os_Timer.cpp
    ../../../../../../../../icub-firmware-shared/embot/core/: embot_core_binary.cpp embot_core.cpp
    ../../../../embot/os/: embot_os_Action.cpp embot_os_rtos.cpp
  group embot-app-protocol
    ../../../../../../eBcode/arch-arm/embot/prot/can/: embot_prot_can.cpp embot_prot_can_analog_periodic.cpp embot_prot_can_analog_polling.cpp embot_prot_can_bootloader.cpp embot_prot_can_inertial_periodic.cpp embot_prot_can_motor_periodic.cpp embot_prot_can_motor_polling.cpp
  group embot-app-parser
    ../../../../../../eBcode/arch-arm/embot/app/: embot_app_application_theCANparserBasic.cpp embot_app_application_theCANparserIMU.cpp
    ../../../../embot/app/: embot_app_application_theCANparserTHERMO.cpp embot_app_application_theCANparserPOS.cpp
  group embot-application
    ../../../../../../eBcode/arch-arm/embot/app/: embot_app_theApplication.cpp embot_app_theJumper.cpp embot_app_theCANboardInfo.cpp embot_app_application_theCANtracer.cpp embot_app_application_theIMU.cpp
    ../../../../embot/app/: embot_app_theLEDmanager.cpp embot_app_application_theTHERMO.cpp embot_app_application_theFAPreader2.cpp
  group embot-hw
    ../../../../../../eBcode/arch-arm/embot/hw/: embot_hw_FlashStorage.cpp embot_hw_FlashBurner.cpp embot_hw_can.cpp embot_hw_sys.cpp embot_hw_flash.cpp embot_hw.cpp embot_hw_bsp.cpp embot_hw_led.cpp
    ../../../../embot/hw/: embot_hw_bno055.cpp embot_hw_gpio.cpp embot_hw_i2c.cpp embot_hw_timer.cpp embot_hw_si7051.cpp embot_hw_tlv493d.cpp embot_hw_i2ce.cpp
  group embot-hw-lowlevel
    ../../../../embot/hw/: embot_hw_lowlevel.cpp
  group embot::hw::bsp
    ../bsp/: embot_hw_bsp_mtb4.cpp
    ../../bsp/: embot_hw_bsp_mtb4fap.cpp
target mtb4fap-mtb4c (6180000::V6.18::ARMCLANG)
  device: STM32L452RCIx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: mtb4fap +hex
  AfterMake: cmd.exe /C copy .\Obj\mtb4fap.hex ..\bin\mtb4fap.hex
  c flags: Optim=6 oTime=1 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: STM32HAL_BOARD_MTB4FAP USE_STM32HAL STM32HAL_DRIVER_V1D3
  c misc: -Wno-pragma-pack -Wno-deprecated-register
  c include: ..\src-plus;..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\eBcode\arch-arm\libs\midware\eventviewer\api;..\..\..\..\..\..\eBcode\arch-arm\embobj\core\exec\multitask;..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core;..\..\..\..\..\..\eBcode\arch-arm\libs\lowlevel\stm32hal\api;..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\..\eBcode\arch-arm\embot\app;..\..\..\..\..\..\eBcode\arch-arm\embot\i2h;..\..\..\..\..\..\eBcode\arch-arm\embot\hw;..\..\..\..\..\..\eBcode\arch-arm\embot\os;..\..\..\..\..\..\eBcode\arch-arm\embot;..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\..\..\..\icub-firmware-shared\can\canProtocolLib;..\..\..\..\embot\app\skeleton;..\..\..\..\embot\prot\can;..\..\bsp
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: .\mtb4fap-appfap.sct
  link misc: --diag_suppress=L6329
