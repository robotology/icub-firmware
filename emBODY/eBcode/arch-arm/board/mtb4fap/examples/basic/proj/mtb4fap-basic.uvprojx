# Keil uVision project mtb4fap-basic.uvprojx, settings and files
target basic-mtb4fap (6180000::V6.18::ARMCLANG)
  device: STM32L452RCIx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: mtb4ctest +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_MTB4FAP STM32HAL_DRIVER_V1D3
  c misc: -Wno-pragma-pack -Wno-deprecated-register
  c include: ..\..\..\..\..\libs\lowlevel\stm32hal\api
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --diag_suppress=L6329
  group main
    ../src/: main-basic.cpp
  group stm32hal
    ../../../../../libs/lowlevel/stm32hal/lib/: stm32hal.mtb4fap.v1D3.lib
  group stm32hal-config
    ../cfg/: stm32hal.startup.mtb4fap.s
software components: CMSIS:CORE 5.6.0
