# Keil uVision project mtb4w-application-v6.uvprojx, settings and files
target mtb4w-ulpro-v190-0offset (6110000::V6.11::.\ARMCLANG)
  device: STM32L443RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00004000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: mtb4w_0offset +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=6 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_MTB4 STM32HAL_DRIVER_V190 APPL_TESTZEROOFFSET
  c misc: -Wno-pragma-pack -Wno-deprecated-register
  c include: ..\src-plus;..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\eBcode\arch-arm\libs\midware\eventviewer\api;..\..\..\..\..\..\eBcode\arch-arm\embobj\core\exec\multitask;..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core;..\..\..\..\..\..\eBcode\arch-arm\libs\lowlevel\stm32hal\api;..\..\..\..\..\..\eBcode\arch-arm\embot\common;..\..\..\..\..\..\eBcode\arch-arm\embot\app;..\..\..\..\..\..\eBcode\arch-arm\embot\i2h;..\..\..\..\..\..\eBcode\arch-arm\embot\hw;..\..\..\..\..\..\eBcode\arch-arm\embot\sys;..\..\..\..\..\..\eBcode\arch-arm\embot;..\src\others;..\..\..\..\..\..\eBcode\arch-arm\embot\tools;..\..\..\..\..\..\eBcode\arch-arm\embot\binary;..\..\..\..\..\..\..\..\icub-firmware-shared\can\canProtocolLib
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x4000
  scatter file: .\mtb4w-application0offset.sct
  link misc: --diag_suppress=L6329
  group main
    ../src/: main-appcan.cpp
    ../../../../embot/app/skeleton/: embot_app_skeleton_os_basic.cpp embot_app_skeleton_os_evthreadcan.cpp
  group stm32hal
    ../../../../libs/lowlevel/stm32hal/lib/: stm32hal.mtb4.v190.lib
  group stm32hal-config
    ../cfg/: stm32hal.startup.mtb4w.v172.s
  group rtos
    ../../../../../../eBcode/arch-arm/libs/highlevel/abslayer/osal/lib/: osal.cm4.dbg.lib
    ../../../../../../eBcode/arch-arm/libs/midware/eventviewer/src/: eventviewer.c
  group embot-core
    ../../../../../../../../icub-firmware-shared/embot/core/: embot_core.cpp embot_core_binary.cpp
    ../../../../../../eBcode/arch-arm/embot/os/: embot_os.cpp embot_os_Thread.cpp embot_os_theCallbackManager.cpp embot_os_theScheduler.cpp embot_os_theTimerManager.cpp embot_os_Timer.cpp
    ../../../../embot/os/: embot_os_Action.cpp embot_os_rtos.cpp
  group embot-app-protocol
    ../../../../../../eBcode/arch-arm/embot/prot/can/: embot_prot_can.cpp embot_prot_can_analog_periodic.cpp embot_prot_can_analog_polling.cpp embot_prot_can_bootloader.cpp embot_prot_can_inertial_periodic.cpp embot_prot_can_motor_periodic.cpp embot_prot_can_motor_polling.cpp embot_prot_can_skin_periodic.cpp
  group embot-app-parser
    ../../../../../../eBcode/arch-arm/embot/app/: embot_app_application_theCANparserBasic.cpp embot_app_application_theCANparserSkin.cpp embot_app_application_theCANparserIMU.cpp
    ../../../../embot/app/: embot_app_application_theCANparserTHERMO.cpp
  group embot-application
    ../../../../../../eBcode/arch-arm/embot/app/: embot_app_theApplication.cpp embot_app_theJumper.cpp embot_app_theCANboardInfo.cpp embot_app_application_theCANtracer.cpp embot_app_application_theSkin.cpp embot_app_application_theIMU.cpp
    ../../../../embot/app/: embot_app_theLEDmanager.cpp embot_app_application_theTHERMO.cpp
  group embot-hw
    ../../../../../../eBcode/arch-arm/embot/hw/: embot_hw_FlashStorage.cpp embot_hw_FlashBurner.cpp embot_hw_can.cpp embot_hw_sys.cpp embot_hw_flash.cpp embot_hw.cpp embot_hw_bsp.cpp embot_hw_led.cpp
    ../../../../embot/hw/: embot_hw_bno055.cpp embot_hw_gpio.cpp embot_hw_i2c.cpp embot_hw_timer.cpp embot_hw_si7051.cpp
  group other-hw
    ../src/others/: AD7147.c I2C_Multi_SDA.c AD7147_Configuration.c if2hw_common.c
  group embot-hw-lowlevel
    ../../../../embot/hw/: embot_hw_lowlevel.cpp
  group embot::hw::bsp
    ../../bsp/: embot_hw_bsp_mtb4.cpp
target mtb4w-ulpro-v190 (6180000::V6.18::ARMCLANG)
  device: STM32L433RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: as above
  output: mtb4w_v190 +hex
  AfterMake: cmd.exe /C copy .\Obj\mtb4w_v190.hex ..\bin\mtb4w.v190.hex
  c flags: Optim=2 oTime=1 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_MTB4 STM32HAL_DRIVER_V190
  c misc: -Wno-pragma-pack -Wno-deprecated-register
  c include: ..\src-plus;..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\eBcode\arch-arm\libs\midware\eventviewer\api;..\..\..\..\..\..\eBcode\arch-arm\embobj\core\exec\multitask;..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core;..\..\..\..\..\..\eBcode\arch-arm\libs\lowlevel\stm32hal\api;..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\..\eBcode\arch-arm\embot\app;..\..\..\..\..\..\eBcode\arch-arm\embot\i2h;..\..\..\..\..\..\eBcode\arch-arm\embot\hw;..\..\..\..\..\..\eBcode\arch-arm\embot\os;..\..\..\..\..\..\eBcode\arch-arm\embot;..\src\others;..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\..\..\..\icub-firmware-shared\can\canProtocolLib;..\..\..\..\embot\app\skeleton;..\..\..\..\embot\prot\can;..\..\bsp
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x4000
  scatter file: .\mtb4w-application-v6.sct
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 5.1.2
