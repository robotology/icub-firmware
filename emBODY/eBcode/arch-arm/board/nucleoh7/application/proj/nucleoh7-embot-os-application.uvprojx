# Keil uVision project nucleoh7-embot-os-application.uvprojx, settings and files
target strain2-v6-ulpro-v190 (6130001::V6.13.1::.\ARMCLANG)
  device: STM32H743ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.5.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: strain2_v190 +hex
  AfterMake: cmd.exe /C copy .\Obj\strain2_v190.hex ..\bin\strain2.v190.hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=8 v6Lto=1 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_STRAIN2 STM32HAL_DRIVER_V190 not_STRAIN2_APP_AT_64K
  c misc: -Wno-pragma-pack -Wno-deprecated-register
  c include: ..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\eBcode\arch-arm\libs\midware\eventviewer\api;..\..\..\..\..\..\eBcode\arch-arm\embobj\core\exec\multitask-;..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core-;..\..\..\..\..\..\eBcode\arch-arm\libs\lowlevel\stm32hal\api;..\..\..\..\..\..\eBcode\arch-arm\embot\common;..\..\..\..\..\..\eBcode\arch-arm\embot\app;..\..\..\..\..\..\eBcode\arch-arm\embot\i2h;..\..\..\..\..\..\eBcode\arch-arm\embot\hw;..\..\..\..\..\..\eBcode\arch-arm\embot\sys;..\..\..\..\..\..\eBcode\arch-arm\embot;..\..\..\..\embot\binary;..\..\..\..\embot\dsp;..\..\..\..\..\..\..\..\icub-firmware-shared\can\canProtocolLib;..\..\..\..\embot\code
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: ROM 0x30000000 size 0x48000
  memory RVCT7: ROM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\strain2-application-v6.sct
  link misc: --diag_suppress=L6329
  group main
    ../src/: main-nucleoh7-embot-os-application.cpp main-nucleoh7-embot-os-application-test-button.cpp
  group stm32hal
    ../../../../libs/lowlevel/stm32hal/lib/: stm32hal.h7.nucleoh7.v180.lib
  group stm32hal-config
    ../cfg/: stm32hal.startup.nucleoh7.s
  group embot-core
    ../../../../../../../../icub-firmware-shared/embot/core/: embot_core.cpp embot_core_binary.cpp embot_core_utils.cpp
  group embot-hw
    ../../../../embot/hw/: embot_hw.cpp embot_hw_bsp.cpp embot_hw_button.cpp embot_hw_gpio.cpp embot_hw_i2c.cpp embot_hw_led.cpp embot_hw_sys.cpp embot_hw_bno055.cpp embot_hw_lowlevel.cpp embot_hw_timer.cpp embot_hw_ads122c04.cpp ads122c04.c
  group embot-os
    ../../../../embot/os/: embot_os.cpp embot_os_Action.cpp embot_os_theCallbackManager.cpp embot_os_theScheduler.cpp embot_os_theTimerManager.cpp embot_os_Thread.cpp embot_os_Timer.cpp
  group osal
    ../../../../libs/highlevel/abslayer/osal/lib/: osal.cm4.dbg.lib
    ../../../../libs/midware/eventviewer/src/: eventviewer.c
  group others
    ../../../../embot/app/: embot_app_theLEDmanager.cpp
    ../../../../../../../../icub-firmware-shared/embot/tools/: embot_tools.cpp
target nucleoh7-0offset-stlink (6140000::V6.14::ARMCLANG)
  device: STM32H743ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.5.0
  cpu: as above
  output: nucleoh7 +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_NUCLEOH7 STM32HAL_DRIVER_V180
  c misc: -Wno-pragma-pack -Wno-deprecated-register
  c include: ..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\embot\hw;..\..\..\..\embot\os;..\..\..\..\embot\app;..\..\..\..\libs\lowlevel\stm32hal\api;..\..\..\..\libs\midware\eventviewer\api;..\..\..\..\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\..\..\icub-firmware-shared\embot\tools
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  link misc: --diag_suppress=L6329
target strain2-v1B0 (6130001::V6.13.1::.\ARMCLANG)
  device: STM32L433RCIx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: strain2_v1B0 +hex
  AfterMake: cmd.exe /C copy .\Obj\strain2_v1B0.hex ..\bin\strain2.v1B0.hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=8 v6Lto=1 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_STRAIN2 STM32HAL_DRIVER_V1B0 not_STRAIN2_APP_AT_64K
  c misc: -Wno-pragma-pack -Wno-deprecated-register
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\strain2-application-v6.sct
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 5.4.0
