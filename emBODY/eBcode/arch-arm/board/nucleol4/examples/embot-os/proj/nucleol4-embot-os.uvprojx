# Keil uVision project nucleol4-embot-os.uvprojx, settings and files
target demo-embot-cmsisos2 (6190000::V6.19::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: n64 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_NUCLEO64 STM32HAL_DRIVER_V1D3
  c misc: -Wno-pragma-pack -Wno-deprecated-register -DEMBOT_USE_rtos_cmsisos2
  c include: ..\..\..\..\..\libs\lowlevel\stm32hal\api;..\..\..\..\..\libs\highlevel\abslayer\cmsisos2\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\embot\hw;..\..\..\..\..\embot\os;..\..\..\..\..\embot\app;..\..\..\..\..\embot\app;..\..\..\bsp
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --diag_suppress=L6329
  group main
    ../src/: main-basic.cpp test-extfault.cpp
  group stm32hal
    ../../../../../libs/lowlevel/stm32hal/lib/: stm32hal.l4.v1D3.nucleol4.lib
  group stm32hal-config
    ../cfg/: stm32hal.startup.nucleol4.s
  group rtos
    ../../../../../libs/highlevel/abslayer/cmsisos2/lib/: cmsisos2.lib
    ../../../../../libs/highlevel/abslayer/osal/lib/: osal.cm4.dbg.lib
    ../../../../../libs/midware/eventviewer/src/: eventviewer.c
  group embot::core
    ../../../../../../../../../icub-firmware-shared/embot/core/: embot_core.cpp embot_core_binary.cpp embot_core_utils.cpp
  group embot::hw
    ../../../../../embot/hw/: embot_hw_bsp.cpp embot_hw.cpp embot_hw_gpio.cpp embot_hw_led.cpp embot_hw_sys.cpp embot_hw_button.cpp embot_hw_can.cpp embot_hw_flash.cpp
  group embot::hw::lowlevel
    ../../../../../embot/hw/: embot_hw_lowlevel.cpp
  group embot::os
    ../../../../../embot/os/: embot_os.cpp embot_os_Action.cpp embot_os_theCallbackManager.cpp embot_os_theScheduler.cpp embot_os_theTimerManager.cpp embot_os_Thread.cpp embot_os_Timer.cpp embot_os_rtos.cpp
  group embot::app
    ../../../../../embot/app/: embot_app_theLEDmanager.cpp
  group embot::hw::bsp
    ../../../bsp/: embot_hw_bsp_nucleol4.cpp
target demo-embot-osal (6190000::V6.19::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: as above
  output: nucleol4 +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_NUCLEOL4 STM32HAL_DRIVER_V1D3
  c misc: -Wno-pragma-pack -Wno-deprecated-register -DEMBOT_USE_rtos_osal
  c include: ..\..\..\..\..\libs\lowlevel\stm32hal\api;..\..\..\..\..\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\embot\hw;..\..\..\..\..\embot\os;..\..\..\..\..\embot\app;..\..\..\..\..\embot\app;..\..\..\..\..\libs\midware\eventviewer\api;..\..\..\bsp
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --diag_suppress=L6329
