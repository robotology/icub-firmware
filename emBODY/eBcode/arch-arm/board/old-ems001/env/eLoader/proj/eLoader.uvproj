# Keil uVision project eLoader.uvproj, settings and files
target mcbstm32c (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: eLoader-updt +hex
  c flags: Optim=1 OneElfS=1
  c define: HAL_USE_ARCH_ARM BOARD_MCBSTM32C DEBUG_MODE
  c misc: --c99
  c include: ..\..\..\..\..\libs\highlevel\abslayer\hal\api;..\..\..\..\..\libs\highlevel\services\embenv\api;..\..\cfg
  asm misc: --cpreproc
  asm include: ..\app
  memory RVCT4: ROM 0x8000000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\eLoader.sct
  group application
    ../app/: loader_updt.c
  group hal
    ../app/: hal_cfg.h hal_cfg.c
    ../../../../../libs/highlevel/abslayer/hal/lib/: hal.ems001.lib hal.mcbstm32c.lib
    ../../../../../libs/highlevel/abslayer/hal/stg/: hal_startup_stm32f107.s
  group arm-services-embenv
    ../../../../../libs/highlevel/services/embenv/src/: eEcommon.c eEsharedServices.c shalBASE.c shalINFO.c shalPART.c
target ems001 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: eLoader_ems001 +hex
  AfterMake: cmd.exe /C copy .\Obj\eLoader_ems001.hex ..\bin\eLoader_ems001.hex
  c flags: Optim=1 OneElfS=1
  c define: HAL_USE_ARCH_ARM BOARD_EMS001
  c misc: --c99
  c include: as above
  asm misc: --cpreproc
  asm include: ..\app
  memory RVCT4: ROM 0x8000000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\eLoader.sct
