# Keil uVision project rfe-application-v6.uvprojx, settings and files
target rfe-ulpro-v183 (6140000::V6.14::ARMCLANG)
  device: STM32L452CEUx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rfe_v183 +hex
  AfterMake: cmd.exe /C copy .\v6-obj\rfe_v183.hex ..\bin\rfe.v183.hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_RFE STM32HAL_DRIVER_V183
  c misc: -Wno-pragma-pack -Wno-deprecated-register
  c include: ..\src-plus;..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\eBcode\arch-arm\libs\midware\eventviewer\api;..\..\..\..\..\..\eBcode\arch-arm\libs\lowlevel\stm32hal\api;..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\..\eBcode\arch-arm\embot\app;..\..\..\..\..\..\eBcode\arch-arm\embot\i2h;..\..\..\..\..\..\eBcode\arch-arm\embot\hw;..\..\..\..\..\..\eBcode\arch-arm\embot\os;..\..\..\..\..\..\eBcode\arch-arm\embot;..\src\others;..\..\..\..\..\..\..\..\icub-firmware-shared\embot\tools;..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\..\eBcode\arch-arm\embot\dsp;..\src\bosch-driver;..\..\..\..\..\..\..\..\icub-firmware-shared\can\canProtocolLib;..\src\STM32_USB_Device_Library\Class\CDC\Inc;..\src\STM32_USB_Device_Library\Core\Inc;..\src\usb_user;..\..\..\..\libs\lowlevel\stm32hal\src\driver\stm32l4-v183\inc-nonsiusa;..\src;..\..\..\..\libs\lowlevel\stm32hal\src\board\rfe\inc-nonisusa;..\src\faceExpressions;..\..\..\..\embot\app\skeleton;..\..\..\..\embot\prot\can
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: .\rfe-application.sct
  link misc: --diag_suppress=L6329
  group main
    ../src/: rfe-application-main-template.cpp
    ../src/faceExpressions/: faceExpressionsDefinitions.h faceExpressionsGifts.cpp faceExpressionsLowLevelDriver.h faceExpressionsModule.cpp faceExpressionsModule.h faceExpressionsTypes.h faceExpressionsLowLevelDriver.cpp faceExpressionsTypes.cpp
    ../../../../embot/app/skeleton/: embot_app_skeleton_os_basic.cpp embot_app_skeleton_os_evthreadcan.cpp
  group stm32hal-v183
    ../../../../../../eBcode/arch-arm/libs/lowlevel/stm32hal/lib/: stm32hal.rfe.v183.lib
  group stm32hal-config
    ../cfg/: stm32hal.startup.rfe.v6.s
  group osal
    ../../../../../../eBcode/arch-arm/libs/highlevel/abslayer/osal/lib/: osal.cm4.dbg.lib
    ../../../../../../eBcode/arch-arm/libs/midware/eventviewer/src/: eventviewer.c
  group embot
    ../../../../../../eBcode/arch-arm/embot/os/: embot_os.cpp embot_os_Thread.cpp embot_os_theCallbackManager.cpp embot_os_theScheduler.cpp embot_os_theTimerManager.cpp embot_os_Timer.cpp
    ../../../../../../eBcode/arch-arm/embot/app/: embot_app_theJumper.cpp
    ../../../../../../../../icub-firmware-shared/embot/tools/: embot_tools.cpp
    ../../../../../../../../icub-firmware-shared/embot/core/: embot_core_binary.cpp embot_core.cpp
    ../../../../embot/os/: embot_os_Action.cpp embot_os_rtos.cpp
  group embot-protocol
    ../../../../../../eBcode/arch-arm/embot/prot/can/: embot_prot_can.cpp embot_prot_can_skin_periodic.cpp embot_prot_can_inertial_periodic.cpp embot_prot_can_motor_polling.cpp embot_prot_can_motor_periodic.cpp embot_prot_can_bootloader.cpp embot_prot_can_analog_polling.cpp embot_prot_can_analog_periodic.cpp
  group embot-parser
    ../../../../../../eBcode/arch-arm/embot/app/: embot_app_application_theCANparserBasic.cpp
    ../../../../embot/app/: embot_app_application_theCANparserIMU.cpp
  group embot-application
    ../../../../embot/app/: embot_app_theLEDmanager.cpp embot_app_application_theIMU.cpp
    ../../../../../../eBcode/arch-arm/embot/app/: embot_app_theApplication.cpp embot_app_theCANboardInfo.cpp embot_app_application_theCANtracer.cpp
  group embot-hw
    ../../../../../../eBcode/arch-arm/embot/hw/: embot_hw.cpp embot_hw_sys.cpp embot_hw_bsp.cpp embot_hw_FlashStorage.cpp embot_hw_FlashBurner.cpp embot_hw_can.cpp embot_hw_flash.cpp embot_hw_timer.cpp embot_hw_gpio.cpp embot_hw_led.cpp embot_hw_button.cpp
    ../src/usb_user/: embot_hw_usb.cpp
    ../../../../embot/hw/: embot_hw_lowlevel.cpp embot_hw_bno055.cpp embot_hw_i2c.cpp
  group usb-stm-lib
    ../src/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../src/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../../../../libs/lowlevel/stm32hal/src/board/rfe/v183/src/: stm32l4xx_hal_msp.c
    ../../../../libs/lowlevel/stm32hal/src/driver/stm32l4-v183/src/: stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c
    ../src/: readme.txt
  group usb-user-def
    ../src/usb_user/: usbd_cdc_if.c usb_device.c usbd_conf.c usbd_desc.c
target rfe-0offset-stlink (6120000::V6.12::.\ARMCLANG)
  device: STM32L452CEUx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00028000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rfe_v6_zero +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=6 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_RFE STM32HAL_DRIVER_V183 EMBOT_APPL_ZEROOFFSET
  c misc: -Wno-pragma-pack -Wno-deprecated-register
  c include: ..\src-plus;..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\eBcode\arch-arm\libs\midware\eventviewer\api;..\..\..\..\..\..\eBcode\arch-arm\embobj\core\exec\multitask;..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core;..\..\..\..\..\..\eBcode\arch-arm\libs\lowlevel\stm32hal\api;..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\..\eBcode\arch-arm\embot\app;..\..\..\..\..\..\eBcode\arch-arm\embot\i2h;..\..\..\..\..\..\eBcode\arch-arm\embot\hw;..\..\..\..\..\..\eBcode\arch-arm\embot\os;..\..\..\..\..\..\eBcode\arch-arm\embot;..\src\others;..\..\..\..\..\..\..\..\icub-firmware-shared\embot\tools;..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\..\eBcode\arch-arm\embot\dsp;..\src\bosch-driver;..\..\..\..\..\..\..\..\icub-firmware-shared\can\canProtocolLib;..\src\STM32_USB_Device_Library\Class\CDC\Inc;..\src\STM32_USB_Device_Library\Core\Inc;..\src\usb_user;..\..\..\..\libs\lowlevel\stm32hal\src\driver\stm32l4-v183\inc-nonsiusa;..\src;..\..\..\..\libs\lowlevel\stm32hal\src\board\rfe\inc-nonisusa;..\src\faceExpressions
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: .\rfe-application0offset.sct
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 5.1.2
