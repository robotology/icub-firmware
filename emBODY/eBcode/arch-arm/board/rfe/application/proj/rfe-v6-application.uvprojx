# Keil uVision project rfe-v6-application.uvprojx, settings and files
target rfe-v6-stlink (6100001::V6.10.1::.\ARMCLANG)
  device: STM32L452CEUx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rfe_v6 +hex
  AfterMake: cmd.exe /C copy .\v6-obj\rfe_v6.hex ..\bin\rfe.v6.hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=6 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_RFE
  c misc: -Wno-pragma-pack -Wno-deprecated-register
  c include: ..\src-plus;..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\eBcode\arch-arm\libs\midware\eventviewer\api;..\..\..\..\..\..\eBcode\arch-arm\embobj\core\exec\multitask;..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core;..\..\..\..\..\..\eBcode\arch-arm\libs\lowlevel\stm32hal\api;..\..\..\..\..\..\eBcode\arch-arm\embot\common;..\..\..\..\..\..\eBcode\arch-arm\embot\app;..\..\..\..\..\..\eBcode\arch-arm\embot\i2h;..\..\..\..\..\..\eBcode\arch-arm\embot\hw;..\..\..\..\..\..\eBcode\arch-arm\embot\sys;..\..\..\..\..\..\eBcode\arch-arm\embot;..\src\others;..\..\..\..\..\..\eBcode\arch-arm\embot\tools;..\..\..\..\..\..\eBcode\arch-arm\embot\binary;..\..\..\..\..\..\eBcode\arch-arm\embot\dsp;..\src\bosch-driver;..\..\..\..\..\..\..\..\icub-firmware-shared\can\canProtocolLib;..\src\STM32_USB_Device_Library\Class\CDC\Inc;..\src\STM32_USB_Device_Library\Core\Inc;..\src\usb_user;..\..\..\..\libs\lowlevel\stm32hal\src\driver\stm32l4-v183\inc-nonsiusa;..\src;..\..\..\..\libs\lowlevel\stm32hal\src\board\rfe\inc-nonisusa;..\src\faceExpressions
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: .\rfe-application.sct
  link misc: --diag_suppress=L6329
  group main
    ../src/: rfe-application-main-template.cpp
    ../src/faceExpressions/: faceExpressionsDefinitions.h faceExpressionsGifts.cpp faceExpressionsLowLevelDriver.h faceExpressionsModule.cpp faceExpressionsModule.h faceExpressionsTypes.h faceExpressionsLowLevelDriver.cpp faceExpressionsTypes.cpp
  group stm32hal
    ../../../../../../eBcode/arch-arm/libs/lowlevel/stm32hal/lib/: stm32hal.v6.rfe.lib
  group stm32hal-config
    ../cfg/: stm32hal.startup.rfe.v6.s
  group osal
    ../../../../../../eBcode/arch-arm/libs/highlevel/abslayer/osal/lib/: osal.cm4.dbg.lib
  group eventviewer
    ../../../../../../eBcode/arch-arm/libs/midware/eventviewer/src/: eventviewer.c
  group embobj-shared
    ../../../../../../../../icub-firmware-shared/eth/embobj/core/core/: EOaction.c EOarray.c EoCommon.c EOconstarray.c EOconstvector.c EOdeque.c EOfifo.c EOfifoByte.c EOfifoWord.c EOlist.c EOpacket.c EOsm.c EOtheErrorManager.c EOtheLEDpulser.c EOtheMemoryPool.c EOtimer.c EOumlsm.c EOvector.c EOVmutex.c EOVtask.c EOVtheCallbackManager.c EOVtheSystem.c EOVtheTimerManager.c
  group embobj-mee
    ../../../../../../eBcode/arch-arm/embobj/core/exec/multitask/: EOMtheTimerManager.c EOMtheCallbackManager.c EOMtask.c EOMmutex.c
  group embot
    ../../../../../../eBcode/arch-arm/embot/common/: embot_common.cpp
    ../../../../../../eBcode/arch-arm/embot/i2h/: embot_i2h.cpp
    ../../../../../../eBcode/arch-arm/embot/sys/: embot_sys.cpp embot_sys_Task.cpp embot_sys_theCallbackManager.cpp embot_sys_theJumper.cpp embot_sys_theScheduler.cpp embot_sys_theStorage.cpp embot_sys_theTimerManager.cpp embot_sys_Timer.cpp slim_retarget_io.c
    ../../../../../../eBcode/arch-arm/embot/tools/: embot_tools.cpp
    ../../../../../../eBcode/arch-arm/embot/binary/: embot_binary.cpp
    ../../../../../../eBcode/arch-arm/embot/dsp/: embot_dsp.cpp
  group embot-protocol
    ../../../../../../eBcode/arch-arm/embot/app/: embot_app_canprotocol.cpp embot_app_canprotocol_skin_periodic.cpp embot_app_canprotocol_inertial_periodic.cpp embot_app_canprotocol_motor_polling.cpp embot_app_canprotocol_motor_periodic.cpp embot_app_canprotocol_bootloader.cpp embot_app_canprotocol_analog_polling.cpp embot_app_canprotocol_analog_periodic.cpp
  group embot-parser
    ../../../../../../eBcode/arch-arm/embot/app/: embot_app_application_theCANparserBasic.cpp
  group embot-application
    ../../../../../../eBcode/arch-arm/embot/app/: embot_app_theApplication.cpp embot_app_theCANboardInfo.cpp embot_app_application_theCANtracer.cpp
  group embot-hw
    ../../../../../../eBcode/arch-arm/embot/hw/: embot_hw.cpp embot_hw_sys.cpp embot_hw_bsp.cpp embot_hw_FlashStorage.cpp embot_hw_FlashBurner.cpp embot_hw_can.cpp embot_hw_flash.cpp embot_hw_timer.cpp embot_hw_gpio.cpp embot_hw_led.cpp embot_hw_button.cpp
    ../src/usb_user/: embot_hw_usb.cpp
  group usb-stm-lib
    ../src/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../src/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../../../../libs/lowlevel/stm32hal/src/board/rfe/src/: stm32l4xx_hal_msp.c
    ../../../../libs/lowlevel/stm32hal/src/driver/stm32l4-v183/src/: stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c
  group usb-user-def
    ../src/usb_user/: usbd_cdc_if.c usb_device.c usbd_conf.c usbd_desc.c
target rfe-v6-0offset-stlink (6100001::V6.10.1::.\ARMCLANG)
  device: STM32L452CEUx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00028000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rfe_v6_zero +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=6 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_RFE APPL_TESTZEROOFFSET
  c misc: -Wno-pragma-pack -Wno-deprecated-register
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: .\rfe-application0offset.sct
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 5.1.2
