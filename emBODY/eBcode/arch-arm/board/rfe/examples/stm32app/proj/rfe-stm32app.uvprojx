# Keil uVision project rfe-stm32app.uvprojx, settings and files
target rfe-stm32app (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L452CEUx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32app
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STM32HAL STM32HAL_BOARD_RFE
  c misc: --cpp11
  c include: ..\..\..\..\..\..\..\eBcode\arch-arm\libs\lowlevel\stm32hal\api
  asm misc: --cpreproc
  asm include: ..\cfg
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: .\rfe-application0offset.sct
  link misc: --diag_suppress=L6329
  group rfe-app
    ../src/: main-application.cpp
  group stm32hal
    ../../../../../../../eBcode/arch-arm/libs/lowlevel/stm32hal/lib/: stm32hal.rfe.lib
    ../../../../../../../eBcode/arch-arm/libs/lowlevel/stm32hal/startup/: stm32hal.startup.rfe.s
  group stm32hal-config
    ../cfg/: stm32hal_stg.h
software components: CMSIS:CORE 5.1.1
