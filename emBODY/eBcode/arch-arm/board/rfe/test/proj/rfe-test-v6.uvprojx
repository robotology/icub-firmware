# Keil uVision project rfe-test-v6.uvprojx, settings and files
target rfe-btl (6180000::V6.18::ARMCLANG)
  device: STM32L452CEUx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rfe_test_v183 +hex
  AfterMake: cmd.exe /C copy .\v6-obj\rfe_test_v183.hex ..\bin\rfe.test.v183.hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_RFE STM32HAL_DRIVER_V183
  c misc: -Wno-pragma-pack -Wno-deprecated-register
  c include: ..\src-plus;..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\eBcode\arch-arm\libs\midware\eventviewer\api;..\..\..\..\..\..\eBcode\arch-arm\libs\lowlevel\stm32hal\api;..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\..\eBcode\arch-arm\embot\app;..\..\..\..\..\..\eBcode\arch-arm\embot\i2h;..\..\..\..\..\..\eBcode\arch-arm\embot\hw;..\..\..\..\..\..\eBcode\arch-arm\embot\os;..\..\..\..\..\..\eBcode\arch-arm\embot;..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\..\..\..\icub-firmware-shared\can\canProtocolLib;..\..\..\..\embot\app\skeleton;..\..\..\..\embot\prot\can;..\..\bsp;..\src\STM32_USB_Device_Library\Core\Inc;..\src\STM32_USB_Device_Library\Class\CDC\Inc;..\src\usb_user
  memory RVCT4: ROM 0x8000000 size 0x1f800
  memory RVCT9: RAM 0x20000020 size 0x1ffe0
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: .\rfe-test.sct
  link misc: --diag_suppress=L6329
  group main
    ../../../../libs/lowlevel/stm32hal/src/board/rfe/v183/src/: stm32l4xx_hal_msp.c
    ../src/: rfe-test-main.cpp rfe-testplan.cpp rfe-tests.h
  group stm32hal-library
    ../../../../../../eBcode/arch-arm/libs/lowlevel/stm32hal/lib/: stm32hal.rfe.v183.lib
  group stm32hal-config
    ../cfg/: stm32hal.startup.rfe.v6.s
  group osal
    ../../../../../../eBcode/arch-arm/libs/highlevel/abslayer/osal/lib/: osal.cm4.dbg.lib
    ../../../../../../eBcode/arch-arm/libs/midware/eventviewer/src/: eventviewer.c
  group embot
    ../../../../../../eBcode/arch-arm/embot/app/: embot_app_theBootloader.cpp embot_app_theCANboardInfo.cpp embot_app_theJumper.cpp embot_app_bootloader_theCANparser.cpp
    ../../../../../../eBcode/arch-arm/embot/os/: embot_os.cpp embot_os_Thread.cpp embot_os_theCallbackManager.cpp embot_os_theScheduler.cpp embot_os_theTimerManager.cpp embot_os_Timer.cpp
    ../../../../../../eBcode/arch-arm/embot/prot/can/: embot_prot_can.cpp embot_prot_can_bootloader.cpp
    ../../../../../../../../icub-firmware-shared/embot/core/: embot_core_binary.cpp embot_core.cpp
    ../../../../embot/app/: embot_app_theLEDmanager.cpp
    ../../../../embot/os/: embot_os_Action.cpp embot_os_rtos.cpp
  group embot-hw
    ../../../../../../eBcode/arch-arm/embot/hw/: embot_hw.cpp embot_hw_bsp.cpp embot_hw_FlashStorage.cpp embot_hw_FlashBurner.cpp embot_hw_can.cpp embot_hw_sys.cpp embot_hw_flash.cpp embot_hw_led.cpp
    ../../../../embot/hw/: embot_hw_timer.cpp embot_hw_gpio.cpp
    ../src/usb_user/: embot_hw_usb.cpp
  group embot-hw-lowlevel
    ../../../../embot/hw/: embot_hw_lowlevel.cpp
  group embot::hw::bsp
    ../../bsp/: embot_hw_bsp_rfe.cpp
  group usb-user-def
    ../src/usb_user/: usb_device.c usbd_cdc_if.c usbd_conf.c usbd_desc.c
  group usb-stm-lib
    ../src/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_ioreq.c usbd_core.c
    ../src/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../../../../libs/lowlevel/stm32hal/src/board/rfe/v183/src/: stm32l4xx_hal_msp.c
    ../../../../libs/lowlevel/stm32hal/src/driver/stm32l4-v183/src/: stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c
software components: CMSIS:CORE 5.1.2
