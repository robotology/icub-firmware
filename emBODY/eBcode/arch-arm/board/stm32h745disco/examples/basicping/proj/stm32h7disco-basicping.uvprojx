# Keil uVision project stm32h7disco-basicping.uvprojx, settings and files
target basicping-stm32h7disco (6160000::V6.16::ARMCLANG)
  device: STM32H745XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.8.0
  cpu: IRAM(0x38000000,0x00010000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: g4eval +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: CORE_CM7 USE_HAL_DRIVER STM32H745xx USE_STM32HAL STM32HAL_BOARD_STM32H745DISCO STM32HAL_DRIVER_V1A0
  c misc: -Wno-pragma-pack -Wno-deprecated-register -DICUBTECH_USE_IPAL
  c include: ..\..\..\..\..\libs\lowlevel\stm32hal\api;..\..\..\..\..\libs\highlevel\abslayer\ipal\api;..\src;..\..\bsp-ipal;..\cfg
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: ..\..\bsp-ipal\stm32h745xx_flash_CM7-udp.sct
  link misc: --diag_suppress=L6329
  group main
    ../src/: main-basicping.cpp
  group stm32hal
    ../../../../../libs/lowlevel/stm32hal/lib/: stm32hal.h7.stm32h745disco.v1A0.lib
  group stm32hal-config
    ../cfg/: startup_stm32h745xx_CM7.s
  group ipal-h7-lib
    ../../../../../libs/highlevel/abslayer/ipal/lib/: ipal.lwip.h7.lib
  group ipal-h7-cfg
    ../cfg/: ipal_cfg2.cpp
  group bsp-ipal
    ../../bsp-ipal/: ipal_hal_eth_stm32h7.c stm32h7xx_ethirqhandler.c
software components: CMSIS:CORE 5.4.0
