# Keil uVision project stm32h745disco-embot-updater.uvprojx, settings and files
target ethdemo-cmsisos2 (6140000::V6.14::ARMCLANG)
  device: STM32H745XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x38000000,0x00010000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: h7eth +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: USE_ZERO_OFFSET EMBOBJ_USE_EMBOT USE_STM32HAL STM32HAL_BOARD_STM32H745DISCO STM32HAL_DRIVER_V190
  c misc: -Wno-pragma-pack -Wno-deprecated-register -DBOARD_ems4 -DEMBOT_USE_rtos_cmsisos2
  c include: ..\..\..\..\..\libs\lowlevel\stm32hal\api;..\..\..\..\..\libs\highlevel\abslayer\cmsisos2\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\embot\hw;..\..\..\..\..\embot\os;..\..\..\..\..\embot\app;..\..\..\..\..\embot\app;..\..\..\..\..\libs\midware\eventviewer\api;..\..\..\..\..\libs\highlevel\abslayer\ipal\api;..\..\..\..\..\libs\highlevel\abslayer\hal2\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core;..\..\..\..\..\embobj\core\exec\multitask;..\..\..\..\..\libs\highlevel\services\embenv\api;..\..\..\..\..\embobj\plus\ipnet;..\..\..\..\..\embobj\plus\embenv;..\src\emb-env;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\icub;..\..\..\..\..\..\..\..\..\icub-firmware-shared\can\canProtocolLib;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\prot\eth;..\..\..\bsp
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x38000000 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x80000
  link misc: --diag_suppress=L6329
  group stm32hal
    ../../../../../libs/lowlevel/stm32hal/lib/: stm32hal.h7.stm32h745disco.v190.lib
  group stm32hal-config
    ../cfg/: stm32hal.h7.startup.stm32h745disco.CM7.s
  group rtos
    ../../../../../libs/highlevel/abslayer/cmsisos2/lib/: cmsisos2.lib
    ../../../../../libs/highlevel/abslayer/osal/lib/: osal.cm4.dbg.lib
    ../../../../../libs/midware/eventviewer/src/: eventviewer.c
  group embot-core
    ../../../../../../../../../icub-firmware-shared/embot/core/: embot_core.cpp embot_core_binary.cpp embot_core_utils.cpp
  group embot-hw
    ../../../../../embot/hw/: embot_hw_bsp.cpp embot_hw.cpp embot_hw_gpio.cpp embot_hw_led.cpp embot_hw_lowlevel.cpp embot_hw_sys.cpp embot_hw_button.cpp embot_hw_can.cpp embot_hw_flash.cpp
  group embot-os
    ../../../../../embot/os/: embot_os.cpp embot_os_Action.cpp embot_os_theCallbackManager.cpp embot_os_theScheduler.cpp embot_os_theTimerManager.cpp embot_os_Thread.cpp embot_os_Timer.cpp embot_os_rtos.cpp
  group embot-app
    ../../../../../embot/app/: embot_app_theLEDmanager.cpp
  group abslayer
    ../../../../../libs/highlevel/abslayer/ipal/lib/: ipal.base.medium.cm4.lib
    ../cfg/: ipal_cfg.c
  group updater-app
    ../src/: main.cpp eupdater.c eupdater_parser.c eupdater_cangtw.c eOcfg_sm_cangtw.c eupdater-info.c updater-core.c
    ../../../../../../../../../icub-firmware-shared/eth/embobj/plus/comm-v2/icub/: EoUpdaterProtocol.c
  group eo-core
    ../../../../../../../../../icub-firmware-shared/eth/embobj/core/core/: EOaction.c EOarray.c EoCommon.c EOconstarray.c EOconstvector.c EOdeque.c EOfifo.c EOfifoByte.c EOfifoWord.c EOlist.c EOpacket.c EOsm.c EOtheErrorManager.c EOtheLEDpulser.c EOtheMemoryPool.c EOtimer.c EOumlsm.c EOvector.c EOVmutex.c EOVtask.c EOVtheCallbackManager.c EOVtheSystem.c EOVtheTimerManager.c
  group eo-mee-embot
    ../../../../../embobj/core/exec/multitask/embot/: EOMmutex.embot.cpp EOMtask.embot.cpp EOMtheCallbackManager.embot.cpp EOMtheSystem.embot.cpp EOMtheTimerManager.embot.cpp
  group eo-ipnet
    ../../../../../embobj/plus/ipnet/: EOMtheIPnet.c EOsocket.c EOsocketDatagram.c EOVtheIPnet.c
  group eo-arm-env
    ../../../../../embobj/plus/embenv/: EOtheARMenvironment.c EOVtheEnvironment.c
  group arm-services-embenv
    ../../../../../libs/highlevel/services/embenv/src/: eEcommon.c eEsharedServices.c shalBASE.c shalINFO.c shalPART.c
  group hal-fake
    ../src/hal-fake/: halfake.cpp
    ../cfg/: hal_core_cfg.c
  group embot::hw::bsp
    ../../../bsp/: embot_hw_bsp_stm32h745disco.cpp
target ethdemo-osal (6150000::V6.15::ARMCLANG)
  device: STM32H745XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: as above
  output: h7eth +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: as above
  c misc: -Wno-pragma-pack -Wno-deprecated-register -DBOARD_ems4 -DEMBOT_USE_rtos_osal
  c include: ..\..\..\..\..\libs\lowlevel\stm32hal\api;..\..\..\..\..\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\embot\hw;..\..\..\..\..\embot\os;..\..\..\..\..\embot\app;..\..\..\..\..\embot\app;..\..\..\..\..\libs\midware\eventviewer\api;..\..\..\..\..\libs\highlevel\abslayer\ipal\api;..\..\..\..\..\libs\highlevel\abslayer\hal2\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core;..\..\..\..\..\embobj\core\exec\multitask;..\..\..\..\..\libs\highlevel\services\embenv\api;..\..\..\..\..\embobj\plus\ipnet;..\..\..\..\..\embobj\plus\embenv;..\src\emb-env;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\icub;..\..\..\..\..\..\..\..\..\icub-firmware-shared\can\canProtocolLib;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\prot\eth;..\..\..\bsp
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x38000000 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x80000
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 5.4.0
