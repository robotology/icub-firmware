# Keil uVision project tlx_udpdemo.uvprojx, settings and files
target stm32h7_ipal_lwip_sys (6140001::V6.14.1::ARMCLANG)
  device: STM32H745XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x38000000,0x00010000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) XRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: tlx_udpdemo
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AC6, notFRAME_QUEUE, IPAL_USE_RTOS_FULL
  c include: .\include;.\include\drv_hal;.\include\rtos;.\src\rtos;..\ipal-lwip\ipal\ipal_api;..\ipal-lwip\ipal\eth_interface;..\ipal-lwip\ipal\rtos;..\ipal-lwip\ipal\rtos\include;..\ipal-lwip\ipal\lwip_config;.\ipal_cfg;..\ipal-lwip\hal_stm32h745_DFP_6.1\include;..\ipal-lwip\hal_stm32h745_DFP_6.1\include\Legacy;.\include\cube_generated;.\src\startup;..\ipal-lwip\cmsis\core;..\ipal-lwip\cmsis\rtos2;..\ipal-lwip\cmsis\driver
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT9: RAM 0x38000000 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\stm32h7disco_ipal_lwip_keil_ac5.sct
  group app
    ./src/: net_thread.c udp_comm_app_thread.c tlx_ipal_aux.c main.c retarget_io.c debug.c
    ./ipal_cfg/: ipal_app_cfg.c
    ./include/: RTE_Components.h
  group ipal/drv_hal
    ./src/drv_hal/: ipal_hal_eth_stm32h7.c
  group ipal/rtos
    ./src/rtos/: ipal_rtos_cmsis_os2.c ipal_lightweight_protect.c RTX_Config.c RTX_Config.h
  group ipal/lib
    ../ipal-lwip/ipal/lib/: ipal_lwip_sys_minimal.lib ipal_lwip_sys_minimal_fq.lib ipal_lwip_sys.lib ipal_lwip_sys_fq.lib
  group cube_generated
    ./src/cube_generated/: stm32h7xx_hal_msp.c stm32h7xx_it.c
  group cmsis/driver
    ../ipal-lwip/cmsis/driver/: EMAC_STM32H7xx.c PHY_LAN8740A.c
  group cmsis/rtos2
    ../ipal-lwip/cmsis/rtos2/: RTX_CM4F.lib rtx_lib.c
  group cmsis/rtos2/lib
    ../../../../libs/highlevel/abslayer/cmsisos2/lib/: cmsisos2.lib
  group device/startup
    ./src/startup/: startup_stm32h745xx.s system_stm32h7xx.c MX_Device.h
  group device/hal
    ../ipal-lwip/hal_stm32h745_DFP_6.1/src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c
target stm32h7_ipal_lwip_sys_fq (6140001::V6.14.1::ARMCLANG)
  device: STM32H745XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: as above
  output: tlx_udpdemo
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AC6, IPAL_USE_RTOS_FULL
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT9: RAM 0x38000000 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\stm32h7disco_ipal_lwip_keil_ac5.sct
target stm32h7_ipal_lwip_sys_minimal (6160000::V6.16::ARMCLANG)
  device: STM32H745XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: as above
  output: tlx_udpdemo
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AC6, IPAL_USE_RTOS_MINIMAL
  c misc: -DUSE_PC104_ADDRESSING
  c include: .\include;.\include\drv_hal;.\include\rtos;.\src\rtos;..\ipal-lwip\ipal\ipal_api;..\ipal-lwip\ipal\eth_interface;..\ipal-lwip\ipal\rtos;..\ipal-lwip\ipal\rtos\include;..\ipal-lwip\ipal\lwip_config;.\ipal_cfg;..\ipal-lwip\hal_stm32h745_DFP_6.1\include;..\ipal-lwip\hal_stm32h745_DFP_6.1\include\Legacy;.\include\cube_generated;.\src\startup;..\ipal-lwip\cmsis\core;..\ipal-lwip\cmsis\rtos2;..\ipal-lwip\cmsis\driver;.\include\aux_funcs;..\ipal-lwip\ipal\ipal_src\extra;.\src\device_callbacks
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT9: RAM 0x38000000 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\stm32h7disco_ipal_lwip_keil_ac5.sct
target stm32h7_ipal_lwip_sys_minimal_fq (6150000::V6.15::ARMCLANG)
  device: STM32H745XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: as above
  output: tlx_udpdemo
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AC6, IPAL_USE_RTOS_MINIMAL
  c include: .\include;.\include\drv_hal;.\include\rtos;.\src\rtos;..\ipal-lwip\ipal\ipal_api;..\ipal-lwip\ipal\eth_interface;..\ipal-lwip\ipal\rtos;..\ipal-lwip\ipal\rtos\include;..\ipal-lwip\ipal\lwip_config;.\ipal_cfg;..\ipal-lwip\hal_stm32h745_DFP_6.1\include;..\ipal-lwip\hal_stm32h745_DFP_6.1\include\Legacy;.\include\cube_generated;.\src\startup;..\ipal-lwip\cmsis\core;..\ipal-lwip\cmsis\rtos2;..\ipal-lwip\cmsis\driver;..\ipal-lwip\ipal\ipal_src\extra;.\src\device_callbacks
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT9: RAM 0x38000000 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\stm32h7disco_ipal_lwip_keil_ac5.sct
target stm32h7_ipal_lwip_IITCMSIS_OS2 (6160000::V6.16::ARMCLANG)
  device: STM32H745XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: as above
  output: tlx_udpdemo
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AC6, notFRAME_QUEUE, IPAL_USE_RTOS_FULL
  c misc: -DUSE_PC104_ADDRESSING
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT9: RAM 0x38000000 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\stm32h7disco_ipal_lwip_keil_ac5.sct
