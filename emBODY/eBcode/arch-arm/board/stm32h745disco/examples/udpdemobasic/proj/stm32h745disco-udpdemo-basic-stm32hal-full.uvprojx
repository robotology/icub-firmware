# Keil uVision project stm32h745disco-udpdemo-basic-stm32hal-full.uvprojx, settings and files
target udpdemo-basic-stm32-full-cmsisos2 (6160000::V6.16::ARMCLANG)
  device: STM32H745XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x38000000,0x00010000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: udpdemobasic +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: AC6 IPAL_USE_RTOS_MINIMAL USE_STM32HAL STM32HAL_BOARD_STM32H745DISCO STM32HAL_DRIVER_V190 STM32H745xx CORE_CM7 USE_HAL_DRIVER
  c misc: -DUSE_PC104_ADDRESSING -Dembotapp_UDPDEMOBASIC -DmodifiedCMSISETH -Wno-pragma-pack -Wno-deprecated-register -DEMBOT_USE_rtos_cmsisos2
  c include: ..\..\..\..\..\libs\lowlevel\stm32hal\api;..\..\..\..\..\libs\highlevel\abslayer\cmsisos2\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\embot\hw;..\..\..\..\..\embot\os;..\..\..\..\..\embot\app;..\..\..\bsp;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\prot\eth;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core;..\..\..\..\..\libs\highlevel\abslayer\ipal\api-so-far-not-used;..\..\ipal-lwip\ipal\ipal_api;..\drv;..\..\ipal-lwip\cmsis\driver;..\src;..\..\ipal-lwip\ipal\eth_interface;..\..\ipal-lwip\ipal\rtos;..\..\ipal-lwip\ipal\rtos\include;..\..\..\..\..\libs\lowlevel\stm32hal\src\driver\stm32h7-v190\inc;..\..\..\..\..\libs\lowlevel\stm32hal\src\board\stm32h745disco\v190\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x38000000 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\stm32h7disco_ipal_lwip_keil_ac5_stm32hal-full.sct
  link misc: --diag_suppress=L6329
  group main
    ../src/: udpdemobasic-main.cpp
  group stm32hal-config
    ../cfg/: stm32hal.h7.startup.stm32h745disco.CM7.s
  group rtos
    ../../../../../libs/highlevel/abslayer/cmsisos2/lib/: cmsisos2.lib
    ../../../../../libs/highlevel/abslayer/osal/lib/: osal.cm4.dbg.lib
    ../../../../../libs/midware/eventviewer/src/: eventviewer.c
  group embot-core
    ../../../../../../../../../icub-firmware-shared/embot/core/: embot_core.cpp embot_core_binary.cpp embot_core_utils.cpp
  group embot-hw
    ../../../../../embot/hw/: embot_hw_bsp.cpp embot_hw.cpp embot_hw_gpio.cpp embot_hw_led.cpp embot_hw_lowlevel.cpp embot_hw_sys.cpp embot_hw_button.cpp embot_hw_can.cpp embot_hw_flash.cpp
  group embot-os
    ../../../../../embot/os/: embot_os.cpp embot_os_Action.cpp embot_os_theCallbackManager.cpp embot_os_theScheduler.cpp embot_os_theTimerManager.cpp embot_os_Thread.cpp embot_os_Timer.cpp embot_os_rtos.cpp
  group embot-app
    ../../../../../embot/app/: embot_app_theLEDmanager.cpp
  group embot::hw::bsp
    ../../../bsp/: embot_hw_bsp_stm32h745disco.cpp
  group ipal
    ../../ipal-lwip/ipal/lib/: ipal.fake.cm4.lib ipal_lwip_sys_minimal.lib
  group ipal-config
    ../cfg/: ipal_cfg_legacy.c ipal_app_cfg.c ipal_lightweight_protect.c
  group ipal-hw-driver
    ../drv/: ipal_hal_eth_stm32h7.c stm32h7xx_ethirqhandler.c
  group eth-cmsis-driver
    ../../ipal-lwip/cmsis/driver/: EMAC_STM32H7xx.c PHY_LAN8740A.c
  group stm32hal-full-stm32hal
    ../../../../../libs/lowlevel/stm32hal/src/stm32hal/: stm32hal.c
  group stm32hal-full-board-stm32h745disco
    ../../../../../libs/lowlevel/stm32hal/src/board/stm32h745disco/v190/src/: board_stm32h745disco_v190.c eth.c gpio.c stm32h7xx_hal_msp.c
  group stm32hal-full-driver-stm32h7-hal-v190
    ../../../../../libs/lowlevel/stm32hal/src/driver/stm32h7-v190/src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cec.c stm32h7xx_hal_comp.c stm32h7xx_hal_cordic.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_dfsdm.c stm32h7xx_hal_dfsdm_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dsi.c stm32h7xx_hal_dts.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_fmac.c stm32h7xx_hal_gfxmmu.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hash.c stm32h7xx_hal_hash_ex.c stm32h7xx_hal_hcd.c stm32h7xx_hal_hrtim.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_i2s.c stm32h7xx_hal_i2s_ex.c stm32h7xx_hal_irda.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_lptim.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_mdios.c stm32h7xx_hal_mdma.c stm32h7xx_hal_mmc.c stm32h7xx_hal_mmc_ex.c stm32h7xx_hal_nand.c stm32h7xx_hal_nor.c stm32h7xx_hal_opamp.c stm32h7xx_hal_opamp_ex.c stm32h7xx_hal_ospi.c stm32h7xx_hal_otfdec.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pssi.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_ramecc.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_rng_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_smartcard.c stm32h7xx_hal_smartcard_ex.c stm32h7xx_hal_smbus.c stm32h7xx_hal_spdifrx.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_swpmi.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_usart_ex.c stm32h7xx_hal_wwdg.c system_stm32h7xx.c system_stm32h7xx_dualcore_boot_cm4_cm7.c system_stm32h7xx-tec.c
  group stm32hal-full-driver-stm32h7-hl-v190
    ../../../../../libs/lowlevel/stm32hal/src/driver/stm32h7-v190/src/: stm32h7xx_ll_adc.c stm32h7xx_ll_bdma.c stm32h7xx_ll_comp.c stm32h7xx_ll_cordic.c stm32h7xx_ll_crc.c stm32h7xx_ll_crs.c stm32h7xx_ll_dac.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_dma.c stm32h7xx_ll_dma2d.c stm32h7xx_ll_exti.c stm32h7xx_ll_fmac.c stm32h7xx_ll_fmc.c stm32h7xx_ll_gpio.c stm32h7xx_ll_hrtim.c stm32h7xx_ll_i2c.c stm32h7xx_ll_lptim.c stm32h7xx_ll_lpuart.c stm32h7xx_ll_mdma.c stm32h7xx_ll_opamp.c stm32h7xx_ll_pwr.c stm32h7xx_ll_rcc.c stm32h7xx_ll_rng.c stm32h7xx_ll_rtc.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_spi.c stm32h7xx_ll_swpmi.c stm32h7xx_ll_tim.c stm32h7xx_ll_usart.c stm32h7xx_ll_usb.c stm32h7xx_ll_utils.c
target udpdemo-basic-osal (6160000::V6.16::ARMCLANG)
  device: STM32H745XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: as above
  output: h7disco +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: TLX_LWIP IPAL_USE_RTOS_MINIMAL USE_STM32HAL STM32HAL_BOARD_STM32H745DISCO STM32HAL_DRIVER_V190
  c misc: -Dembotapp_UDPDEMOBASIC -DmodifiedCMSISETH -Wno-pragma-pack -Wno-deprecated-register -DEMBOT_USE_rtos_osal
  c include: ..\..\..\..\..\libs\highlevel\abslayer\osal\api;..\..\..\..\..\libs\lowlevel\stm32hal\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\embot\hw;..\..\..\..\..\embot\os;..\..\..\..\..\embot\app;..\..\..\bsp;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\prot\eth;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core;..\..\..\..\..\libs\highlevel\abslayer\ipal\api-so-far-not-used;..\..\ipal-lwip\ipal\ipal_api;..\drv;..\..\ipal-lwip\cmsis\driver;..\..\good-ipal\eth_interface;..\src;..\..\..\..\..\libs\midware\eventviewer\api;..\..\ipal-lwip\ipal\rtos;..\..\ipal-lwip\ipal\rtos\include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x38000000 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\stm32h7disco_ipal_lwip_keil_ac5.sct
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 5.4.0
