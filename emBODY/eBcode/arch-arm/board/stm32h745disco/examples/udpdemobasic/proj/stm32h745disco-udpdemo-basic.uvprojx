# Keil uVision project stm32h745disco-udpdemo-basic.uvprojx, settings and files
target udpdemo-basic-cmsisos2 (6160000::V6.16::ARMCLANG)
  device: STM32H745XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x38000000,0x00010000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: udpdemobasic +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: AC6 IPAL_USE_RTOS_MINIMAL USE_STM32HAL STM32HAL_BOARD_STM32H745DISCO STM32HAL_DRIVER_V190
  c misc: -DUSE_PC104_ADDRESSING -Dembotapp_UDPDEMOBASIC -DmodifiedCMSISETH -Wno-pragma-pack -Wno-deprecated-register -DEMBOT_USE_rtos_cmsisos2
  c include: ..\..\..\..\..\libs\lowlevel\stm32hal\api;..\..\..\..\..\libs\highlevel\abslayer\cmsisos2\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\embot\hw;..\..\..\..\..\embot\os;..\..\..\..\..\embot\app;..\..\..\bsp;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\prot\eth;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core;..\..\..\..\..\libs\highlevel\abslayer\ipal\api-so-far-not-used;..\..\ipal-lwip\ipal\ipal_api;..\drv;..\..\ipal-lwip\cmsis\driver;..\src;..\..\good-ipal\eth_interface;..\..\ipal-lwip\ipal\rtos;..\..\ipal-lwip\ipal\rtos\include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x38000000 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\stm32h7disco_ipal_lwip_keil_ac5.sct
  link misc: --diag_suppress=L6329
  group main
    ../src/: udpdemobasic-main.cpp
  group stm32hal
    ../../../../../libs/lowlevel/stm32hal/lib/: stm32hal.h7.stm32h745disco.v190.lib
  group stm32hal-config
    ../cfg/: stm32hal.h7.startup.stm32h745disco.CM7.s
  group rtos
    ../../../../../libs/highlevel/abslayer/cmsisos2/lib/: cmsisos2.lib
    ../../../../../libs/highlevel/abslayer/osal/lib/: osal.cm4.dbg.lib
    ../../../../../libs/midware/eventviewer/src/: eventviewer.c
  group embot-core
    ../../../../../../../../../icub-firmware-shared/embot/core/: embot_core.cpp embot_core_binary.cpp embot_core_utils.cpp
  group embot-hw
    ../../../../../embot/hw/: embot_hw_bsp.cpp embot_hw.cpp embot_hw_gpio.cpp embot_hw_led.cpp embot_hw_lowlevel.cpp embot_hw_sys.cpp embot_hw_button.cpp embot_hw_can.cpp embot_hw_flash.cpp
  group embot-os
    ../../../../../embot/os/: embot_os.cpp embot_os_Action.cpp embot_os_theCallbackManager.cpp embot_os_theScheduler.cpp embot_os_theTimerManager.cpp embot_os_Thread.cpp embot_os_Timer.cpp embot_os_rtos.cpp
  group embot-app
    ../../../../../embot/app/: embot_app_theLEDmanager.cpp
  group embot::hw::bsp
    ../../../bsp/: embot_hw_bsp_stm32h745disco.cpp
  group ipal
    ../../ipal-lwip/ipal/lib/: ipal.fake.cm4.lib ipal_lwip_sys_minimal.lib
  group ipal-config
    ../cfg/: ipal_cfg_legacy.c ipal_app_cfg.c ipal_lightweight_protect.c
  group ipal-hw-driver
    ../drv/: ipal_hal_eth_stm32h7.c stm32h7xx_ethirqhandler.c
  group eth-cmsis-driver
    ../../ipal-lwip/cmsis/driver/: EMAC_STM32H7xx.c PHY_LAN8740A.c
target udpdemo-basic-osal (6160000::V6.16::ARMCLANG)
  device: STM32H745XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: as above
  output: h7disco +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: TLX_LWIP IPAL_USE_RTOS_MINIMAL USE_STM32HAL STM32HAL_BOARD_STM32H745DISCO STM32HAL_DRIVER_V190
  c misc: -Dembotapp_UDPDEMOBASIC -DmodifiedCMSISETH -Wno-pragma-pack -Wno-deprecated-register -DEMBOT_USE_rtos_osal
  c include: ..\..\..\..\..\libs\highlevel\abslayer\osal\api;..\..\..\..\..\libs\lowlevel\stm32hal\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\embot\hw;..\..\..\..\..\embot\os;..\..\..\..\..\embot\app;..\..\..\bsp;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\prot\eth;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core;..\..\..\..\..\libs\highlevel\abslayer\ipal\api-so-far-not-used;..\..\ipal-lwip\ipal\ipal_api;..\drv;..\..\ipal-lwip\cmsis\driver;..\..\good-ipal\eth_interface;..\src;..\..\..\..\..\libs\midware\eventviewer\api;..\..\ipal-lwip\ipal\rtos;..\..\ipal-lwip\ipal\rtos\include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x38000000 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\stm32h7disco_ipal_lwip_keil_ac5.sct
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 5.4.0
