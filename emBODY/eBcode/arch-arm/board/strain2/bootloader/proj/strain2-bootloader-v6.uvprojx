# Keil uVision project strain2-bootloader-v6.uvprojx, settings and files
target strain2-btl-v5-ulpro (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L433RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00004000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: strain2_bootloader +hex
  AfterMake: cmd.exe /C copy .\Obj\strain2_bootloader.hex ..\bin\strain2.bootloader.hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32HAL_BOARD_STRAIN2
  c misc: --cpp11
  c include: ..\src-plus;..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\eBcode\arch-arm\libs\midware\eventviewer\api;..\..\..\..\..\..\eBcode\arch-arm\embobj\core\exec\multitask;..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core;..\..\..\..\..\..\eBcode\arch-arm\libs\lowlevel\stm32hal\api;..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\..\eBcode\arch-arm\embot\app;..\..\..\..\..\..\eBcode\arch-arm\embot\i2h;..\..\..\..\..\..\eBcode\arch-arm\embot\hw;..\..\..\..\..\..\eBcode\arch-arm\embot\os;..\..\..\..\..\..\eBcode\arch-arm\embot;..\..\..\..\..\..\eBcode\arch-arm\embot\binary;..\..\..\..\..\..\..\..\icub-firmware-shared\can\canProtocolLib
  asm misc: --cpreproc
  asm include: ..\cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x4000
  scatter file: .\strain2-bootloader.sct
  link misc: --diag_suppress=L6329
  group main
    ../src/: main-bootloader.cpp
    ../../../../embot/app/skeleton/: embot_app_skeleton_os_bootloader.cpp
  group stm32hal
    ../../../../../../eBcode/arch-arm/libs/lowlevel/stm32hal/lib/: stm32hal.strain2.v190.lib
  group stm32hal-config
    ../cfg/: stm32hal.startup.strain2.v190.s
  group rtos
    ../../../../../../eBcode/arch-arm/libs/highlevel/abslayer/osal/lib/: osal.cm4.dbg.lib
    ../../../../libs/midware/eventviewer/src/: eventviewer.c
    ../../../../libs/highlevel/abslayer/cmsisos2/lib/: cmsisos2.lib
  group embot
    ../../../../../../../../icub-firmware-shared/embot/core/: embot_core.cpp embot_core_binary.cpp
    ../../../../../../eBcode/arch-arm/embot/app/: embot_app_theBootloader.cpp embot_app_theCANboardInfo.cpp embot_app_theJumper.cpp embot_app_bootloader_theCANparser.cpp
    ../../../../../../eBcode/arch-arm/embot/os/: embot_os.cpp embot_os_Thread.cpp embot_os_theCallbackManager.cpp embot_os_theScheduler.cpp embot_os_theTimerManager.cpp embot_os_Timer.cpp
    ../../../../../../eBcode/arch-arm/embot/prot/can/: embot_prot_can.cpp embot_prot_can_bootloader.cpp
    ../../../../embot/os/: embot_os_Action.cpp embot_os_rtos.cpp
    ../../../../embot/app/: embot_app_theLEDmanager.cpp
  group embot-hw
    ../../../../../../eBcode/arch-arm/embot/hw/: embot_hw.cpp embot_hw_bsp.cpp embot_hw_FlashStorage.cpp embot_hw_FlashBurner.cpp embot_hw_can.cpp embot_hw_sys.cpp embot_hw_flash.cpp embot_hw_led.cpp
    ../../../../embot/hw/: embot_hw_gpio.cpp embot_hw_timer.cpp
  group embot-hw-lowlevel
    ../../../../embot/hw/: embot_hw_lowlevel.cpp
target strain2-btl-v190 (6140000::V6.14::ARMCLANG)
  device: STM32L433RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.4.0
  cpu: as above
  output: strain2_v190_bootloader +hex
  AfterMake: cmd.exe /C copy .\Obj\strain2_v190_bootloader.hex ..\bin\strain2.v190.bootloader.hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=8 v6Lto=1 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_STRAIN2 STM32HAL_DRIVER_V190 notSTRAIN2_APP_AT_128K
  c misc: -Wno-pragma-pack -Wno-deprecated-register
  c include: ..\src-plus;..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\eBcode\arch-arm\libs\midware\eventviewer\api;..\..\..\..\..\..\eBcode\arch-arm\embobj\core\exec\multitask;..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core;..\..\..\..\..\..\eBcode\arch-arm\libs\lowlevel\stm32hal\api;..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\..\eBcode\arch-arm\embot\app;..\..\..\..\..\..\eBcode\arch-arm\embot\i2h;..\..\..\..\..\..\eBcode\arch-arm\embot\hw;..\..\..\..\..\..\eBcode\arch-arm\embot\os;..\..\..\..\..\..\..\..\icub-firmware-shared\can\canProtocolLib;..\..\..\..\embot\app\skeleton;..\..\..\..\embot\prot\can
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x4000
  scatter file: .\strain2-bootloader-v6.sct
  link misc: --diag_suppress=L6329
target strain2-btl-v190-cmsios2 (6140000::V6.14::ARMCLANG)
  device: STM32L433RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.4.0
  cpu: as above
  output: strain2_v190_bootloader +hex
  AfterMake: as above
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=8 v6Lto=1 wLevel=3
  c define: EMBOT_USE_rtos_cmsisos2 USE_STM32HAL STM32HAL_BOARD_STRAIN2 STM32HAL_DRIVER_V190 notSTRAIN2_APP_AT_128K
  c misc: -Wno-pragma-pack -Wno-deprecated-register
  c include: ..\src-plus;..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\cmsisos2\api;..\..\..\..\..\..\eBcode\arch-arm\embobj\core\exec\multitask;..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core;..\..\..\..\..\..\eBcode\arch-arm\libs\lowlevel\stm32hal\api;..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\..\eBcode\arch-arm\embot\app;..\..\..\..\..\..\eBcode\arch-arm\embot\i2h;..\..\..\..\..\..\eBcode\arch-arm\embot\hw;..\..\..\..\..\..\eBcode\arch-arm\embot\os;..\..\..\..\..\..\..\..\icub-firmware-shared\can\canProtocolLib;..\..\..\..\embot\app\skeleton;..\..\..\..\embot\prot\can
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x4000
  scatter file: .\strain2-bootloader-v6.sct
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 5.1.2
