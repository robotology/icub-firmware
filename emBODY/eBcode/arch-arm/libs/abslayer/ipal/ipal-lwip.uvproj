# Keil uVision project ipal-lwip.uvproj, settings and files
target ipal-lwip.base.medium (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: ipal-lwip.base.medium (library)
  AfterMake: cmd.exe /C copy .\Obj\ipal-lwip.base.medium.lib .\lib\ipal-lwip.base.medium.lib
  c flags: Optim=4 oTime=1
  c define: IPAL_MODE_BASE IPAL_MEMORY_MEDIUM
  c misc: --c99
  c include: .\ipal-lwip-src;.\ipal-lwip-src\extra;.\ipal-lwip-src\lwip-1.3.2\src\include;.\ipal-lwip-src\lwip-1.3.2\src\include\ipv4;.\ipal-lwip-src\lwip-1.3.2\src\include\netif;.\ipal-lwip-src\lwip-1.3.2\src\include\lwip;.\api
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group ipal
    ./ipal-lwip-src/: ipal_arp.c ipal_base.c ipal_dhcp.c ipal_eth.c ipal_ftp.c ipal_igmp.c ipal_sys.c ipal_tcp.c ipal_telnet.c ipal_tftp.c ipal_udp.c
  group extra
    ./ipal-lwip-src/extra/: ipal_ipiit_storage.c
  group utilities
    ./ipal-lwip-src/: ipal_fifo_hid.c
  group lwip
    ./ipal-lwip-src/lwip-1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ./ipal-lwip-src/lwip-1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ./ipal-lwip-src/lwip-1.3.2/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ./ipal-lwip-src/lwip-1.3.2/src/netif/: etharp.c ethernetif.c loopif.c slipif.c
