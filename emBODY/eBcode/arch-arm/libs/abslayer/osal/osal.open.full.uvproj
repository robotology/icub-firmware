# Keil uVision project osal.open.full.uvproj, settings and files
target osal.open.full.cm3 (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: osal.open.cm3 (library)
  AfterMake: cmd.exe /C copy .\Obj\osal.open.cm3.lib .\lib\osal.open.cm3.lib
  c flags: Optim=4 oTime=1 OneElfS=1
  c define: OOSIIT_USE_EXTERNAL_TREADSAFETY OSAL_CPUFAM_CM3 __CORTEX_M3 NDBG_MSG OOSIIT_USE_TIMEGET_UNDER_SVC
  c misc: --c99
  c include: .\api;..\..\midware\oosiit\api;..\..\midware\oosiit\src\cmsis-rtx-modified\cm;..\..\midware\oosiit\src\others
  group oosiit
    ../../midware/oosiit/src/cmsis-rtx-modified/cm/: HAL_CM.c HAL_CM3.c HAL_CM4.c rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Memory.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c SVC_Table.s
    ../../midware/oosiit/src/others/: oosiit.c rt_iit_AdvTimer.c rt_iit_changes.c rt_iit_memory.c oosiit_storage.c
  group osal
    ./src/: osal-oosiit.c
target osal.open.full.cm3.dbg (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: osal.open.cm3.dbg (library)
  AfterMake: cmd.exe /C copy .\Obj\osal.open.cm3.dbg.lib .\lib\osal.open.cm3.dbg.lib
  c flags: Optim=4 oTime=1 OneElfS=1
  c define: OOSIIT_USE_EXTERNAL_TREADSAFETY OSAL_CPUFAM_CM3 __CORTEX_M3 OOSIIT_DBG_ENABLE OOSIIT_USE_TIMEGET_UNDER_SVC
  c misc: --c99
  c include: .\api;..\..\midware\oosiit\api;..\..\midware\oosiit\src\cmsis-rtx-modified\cm;..\..\midware\oosiit\src\others;..\..\midware\eventviewer
target osal.open.full.cm4 (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: osal.open.cm4 (library)
  AfterMake: cmd.exe /C copy .\Obj\osal.open.cm4.lib .\lib\osal.open.cm4.lib
  c flags: Optim=4 oTime=1 OneElfS=1
  c define: OOSIIT_USE_EXTERNAL_TREADSAFETY OSAL_CPUFAM_CM4 __CORTEX_M4 __FPU_PRESENT OOSIIT_USE_TIMEGET_UNDER_SVC
  c misc: --c99
  c include: as above
target osal.open.full.cm4.dbg (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: osal.open.cm4.dbg (library)
  AfterMake: cmd.exe /C copy .\Obj\osal.open.cm4.dbg.lib .\lib\osal.open.cm4.dbg.lib
  c flags: Optim=4 oTime=1 OneElfS=1
  c define: OOSIIT_USE_EXTERNAL_TREADSAFETY OSAL_CPUFAM_CM4 __CORTEX_M4 __FPU_PRESENT OOSIIT_DBG_ENABLE OOSIIT_USE_TIMEGET_UNDER_SVC
  c misc: --c99
  c include: as above
