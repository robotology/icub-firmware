# Keil uVision project cmsisos2.uvprojx, settings and files
target CM0_LE (6110000::V6.11::.\ARMCLANG)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: RTX_CM0 (library)
  AfterMake: cmd.exe /C copy CM0_LE\RTX_CM0.lib ..\.
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EVR_RTX_DISABLE
  c include: ..\..\..\Config;..\..\..\Include;..\..\..\..\Include
  asm misc: --no_hide_all
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Core
    ./src/RTOS2/RTX/Source/: rtx_kernel.c rtx_thread.c rtx_delay.c rtx_timer.c rtx_evflags.c rtx_mutex.c rtx_semaphore.c rtx_memory.c rtx_mempool.c rtx_msgqueue.c rtx_system.c rtx_evr.c
    ./src/RTOS2/Source/: os_systick.c
  group Handlers
    ./src/RTOS2/RTX/Source/ARM/: irq_cm0.s irq_cm3.s irq_cm4f.s irq_armv8mbl.s irq_armv8mml.s
  group others
    ./src/RTOS2/RTX/Source/: rtx_lib.c
    ./src/extra/: extra.c
target CM3_LE (6110000::V6.11::.\ARMCLANG)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: RTX_CM3 (library)
  AfterMake: cmd.exe /C copy CM3_LE\RTX_CM3.lib ..\.
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EVR_RTX_DISABLE
  c include: ..\..\..\Config;..\..\..\Include;..\..\..\..\Include
  asm misc: --no_hide_all
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
target CM4F_LE (6160000::V6.16::ARMCLANG)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: RTX_CM4F (library)
  AfterMake: cmd.exe /C copy CM4F_LE\RTX_CM4F.lib .\lib\cmsisos2.lib
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EVR_RTX_DISABLE CMSISOS2_ICUB_CHANGES
  c include: .\src\RTOS2\Include;.\src\RTOS2\RTX\Config;.\src\RTOS2\RTX\Include;.\api;.\src\RTOS2\RTX\Source;.\src\rte;.\src\cmsis5\cmsis\core\include;.\src\cmsis5\device\arm\armcm4\include
  asm misc: --no_hide_all
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
target ARMv8MBL_LE (6110000::V6.11::.\ARMCLANG)
  device: ARMv8MBL ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("ARMV8MBL") CLOCK(12000000) ELITTLE
  output: RTX_V8MB (library)
  AfterMake: cmd.exe /C copy ARMv8MBL_LE\RTX_V8MB.lib ..\.
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EVR_RTX_DISABLE
  c include: ..\..\..\Config;..\..\..\Include;..\..\..\..\Include
  asm misc: --no_hide_all
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
target ARMv8MBL_NS_LE (6110000::V6.11::.\ARMCLANG)
  device: ARMv8MBL ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: RTX_V8MBN (library)
  AfterMake: cmd.exe /C copy ARMv8MBL_NS_LE\RTX_V8MBN.lib ..\.
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EVR_RTX_DISABLE DOMAIN_NS=1
  c include: ..\..\..\Config;..\..\..\Include;..\..\..\..\Include
  asm define: DOMAIN_NS=1
  asm misc: --no_hide_all
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
target ARMv8MML_LE (6110000::V6.11::.\ARMCLANG)
  device: ARMv8MML ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("ARMV8MML") CLOCK(12000000) ELITTLE
  output: RTX_V8MM (library)
  AfterMake: cmd.exe /C copy ARMv8MML_LE\RTX_V8MM.lib ..\.
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EVR_RTX_DISABLE
  c include: ..\..\..\Config;..\..\..\Include;..\..\..\..\Include
  asm misc: --no_hide_all
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
target ARMv8MML_NS_LE (6110000::V6.11::.\ARMCLANG)
  device: ARMv8MML ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: RTX_V8MMN (library)
  AfterMake: cmd.exe /C copy ARMv8MML_NS_LE\RTX_V8MMN.lib ..\.
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EVR_RTX_DISABLE DOMAIN_NS=1
  c include: ..\..\..\Config;..\..\..\Include;..\..\..\..\Include
  asm define: DOMAIN_NS=1
  asm misc: --no_hide_all
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
target ARMv8MML_SP_LE (6110000::V6.11::.\ARMCLANG)
  device: ARMv8MML_SP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("ARMV8MML") FPU3(SFPU) CLOCK(12000000) ESEL ELITTLE
  output: RTX_V8MMF (library)
  AfterMake: cmd.exe /C copy ARMv8MML_SP_LE\RTX_V8MMF.lib ..\.
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EVR_RTX_DISABLE
  c include: ..\..\..\Config;..\..\..\Include;..\..\..\..\Include
  asm misc: --no_hide_all
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
target ARMv8MML_SP_NS_LE (6110000::V6.11::.\ARMCLANG)
  device: ARMv8MML_SP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: RTX_V8MMFN (library)
  AfterMake: cmd.exe /C copy ARMv8MML_SP_NS_LE\RTX_V8MMFN.lib ..\.
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EVR_RTX_DISABLE DOMAIN_NS=1
  c include: ..\..\..\Config;..\..\..\Include;..\..\..\..\Include
  asm define: DOMAIN_NS=1
  asm misc: --no_hide_all
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
