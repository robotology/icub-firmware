# Keil uVision project cmsisrtx.uvprojx, settings and files
target debug.cm4 (6240000::V6.24::ARMCLANG)
  device: STM32H747AIIx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.0
  cpu: IRAM(0x10000000,0x00048000) IROM(0x08100000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: cmsisrtx_debug_cm4 (library)
  AfterMake: cmd.exe /C copy obj\debug.cm4\cmsisrtx_debug_cm4.lib ..\lib\cmsisrtx.debug.cm4.lib
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EVR_RTX_DISABLE CMSISRTX_EVENTVIEWER _RTE_ CMSISRTX_CM4
  c include: ..\cfg;..\api;..\src\CMSIS-RTX\Include;..\src\CMSIS-RTX\Source;..\src\extra;..\src\CMSIS_6\CMSIS\RTOS2\Include;..\src\CMSIS_6\CMSIS\Core\Include
  asm define: _RTE_ CMSISRTX_CM4
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group RTX kernel
    ../src/CMSIS-RTX/Source/: rtx_kernel.c rtx_thread.c rtx_delay.c rtx_timer.c rtx_evflags.c rtx_mutex.c rtx_semaphore.c rtx_memory.c rtx_mempool.c rtx_msgqueue.c rtx_system.c rtx_evr.c
    ../src/extra/: cmsisrtx_eventviewer.c
  group RTX handlers
    ../src/extra/: cmsisrtx_irq.c
  group OS tick
    ../src/CMSIS_6/CMSIS/RTOS2/Source/: os_systick.c
  group api and cfg
    ../api/: cmsisrtx.h
    ../cfg/: RTX_Config.h RTX_Config.c cmsisrtx_lib.c
  group extra
    ../src/extra/: cmsisrtx_device.h RTE_Components.h
target fast.cm4 (6240000::V6.24::ARMCLANG)
  device: STM32H747AIIx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.0
  cpu: as above
  output: cmsisrtx_fast_cm4 (library)
  AfterMake: cmd.exe /C copy obj\fast.cm4\cmsisrtx_fast_cm4.lib ..\lib\cmsisrtx.fast.cm4.lib
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EVR_RTX_DISABLE CMSISRTX_FAST _RTE_ CMSISRTX_CM4
  c include: as above
  asm define: CMSISRTX_FAST _RTE_ CMSISRTX_CM4
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
target debug.cm7 (6240000::V6.24::ARMCLANG)
  device: STM32H747AIIx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) XRAM(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: cmsisrtx_debug_cm7 (library)
  AfterMake: cmd.exe /C copy obj\debug.cm7\cmsisrtx_debug_cm7.lib ..\lib\cmsisrtx.debug.cm7.lib
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EVR_RTX_DISABLE CMSISRTX_EVENTVIEWER _RTE_ CMSISRTX_CM7
  c include: as above
  asm define: _RTE_ CMSISRTX_CM7
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT6: ROM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
target fast.cm7 (6240000::V6.24::ARMCLANG)
  device: STM32H747AIIx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.0
  cpu: as above
  output: cmsisrtx_fast_cm7 (library)
  AfterMake: cmd.exe /C copy obj\fast.cm7\cmsisrtx_fast_cm7.lib ..\lib\cmsisrtx.fast.cm7.lib
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EVR_RTX_DISABLE CMSISRTX_FAST _RTE_ CMSISRTX_CM7
  c include: as above
  asm define: CMSISRTX_FAST _RTE_ CMSISRTX_CM7
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT6: ROM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
