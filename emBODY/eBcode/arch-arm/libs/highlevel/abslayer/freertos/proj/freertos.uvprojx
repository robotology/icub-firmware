# Keil uVision project freertos.uvprojx, settings and files
target debug.cm4 (6240000::V6.24::ARMCLANG)
  device: STM32H747AIIx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.0
  cpu: IRAM(0x10000000,0x00048000) IROM(0x08100000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: freertos_debug_cm4 (library)
  AfterMake: cmd.exe /C copy obj\debug.cm4\freertos_debug_cm4.lib ..\lib\freertos.debug.cm4.lib
  c flags: Optim=6 OneElfS=1 v6Lang=6 v6LangP=3 wLevel=2
  c define: FREERTOS_LIB_CM4 FREERTOS_EVENTVIEWER
  c include: ..\cfg;..\src\extra;..\src\FreeRTOS-Kernel\include;..\src\FreeRTOS-Kernel\portable\GCC\ARM_CM4F
  asm define: FREERTOS_LIB_CM4
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group FreeRTOS kernel
    ../src/FreeRTOS-Kernel/: tasks.c queue.c list.c timers.c
  group FreeRTOS port
    ../src/FreeRTOS-Kernel/portable/GCC/ARM_CM4F/: port.c portmacro.h
  group api and cfg
    ../src/extra/: freertos_api.h
    ../cfg/: FreeRTOSConfig.h freertos_lib.c freertos_eventviewer.c
target fast.cm4 (6240000::V6.24::ARMCLANG)
  device: STM32H747AIIx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.0
  cpu: as above
  output: freertos_fast_cm4 (library)
  AfterMake: cmd.exe /C copy obj\fast.cm4\freertos_fast_cm4.lib ..\lib\freertos.fast.cm4.lib
  c flags: Optim=6 OneElfS=1 v6Lang=6 v6LangP=3 wLevel=2
  c define: FREERTOS_LIB_CM4 FREERTOS_FAST
  c include: as above
  asm define: FREERTOS_LIB_CM4
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
target debug.cm7 (6240000::V6.24::ARMCLANG)
  device: STM32H747AIIx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) XRAM(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: freertos_debug_cm7 (library)
  AfterMake: cmd.exe /C copy obj\debug.cm7\freertos_debug_cm7.lib ..\lib\freertos.debug.cm7.lib
  c flags: Optim=6 OneElfS=1 v6Lang=6 v6LangP=3 wLevel=2
  c define: FREERTOS_LIB_CM7 FREERTOS_EVENTVIEWER
  c include: as above
  asm define: FREERTOS_LIB_CM7
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT6: ROM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
target fast.cm7 (6240000::V6.24::ARMCLANG)
  device: STM32H747AIIx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.0
  cpu: as above
  output: freertos_fast_cm7 (library)
  AfterMake: cmd.exe /C copy obj\fast.cm7\freertos_fast_cm7.lib ..\lib\freertos.fast.cm7.lib
  c flags: Optim=6 OneElfS=1 v6Lang=6 v6LangP=3 wLevel=2
  c define: FREERTOS_LIB_CM7 FREERTOS_FAST
  c include: as above
  asm define: FREERTOS_LIB_CM7
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT6: ROM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
