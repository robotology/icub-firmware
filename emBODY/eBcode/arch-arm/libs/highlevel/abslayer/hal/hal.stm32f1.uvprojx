# Keil uVision project hal.stm32f1.uvprojx, settings and files
target hal.mcbstm32c (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: hal_mcbstm32c (library)
  AfterMake: cmd.exe /C copy .\Obj\hal_mcbstm32c.lib .\lib\hal.mcbstm32c.lib
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1
  c define: STM32F10X_CL HAL_USE_ARCH_ARM HAL_BOARD_MCBSTM32C
  c include: .\api;.\src\stm32f1;..\..\..\lowlevel\hl-core\cmsis\api;..\..\..\lowlevel\hl-core\stm32f1\api;..\..\..\lowlevel\hl-core\stm32f1\src
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group hl-cmsis
    ../../../lowlevel/hl-core/cmsis/src/: system_stm32f10x.c
  group hl-core-stm32f1
    ../../../lowlevel/hl-core/stm32f1/src/: stm32f10x__misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group hal-stm32f1
    ./src/stm32f1/: hal_stm32_arch.c hal_stm32_base.c hal_stm32_crc.c hal_stm32_display.c hal_stm32_eeprom.c hal_stm32_encoder.c hal_stm32_eth.c hal_stm32_eth-lwip.c hal_stm32_flash.c hal_stm32_gpio.c hal_stm32_led.c hal_stm32_switch.c hal_stm32_sys.c hal_stm32_timer.c hal_stm32_trace.c hal_stm32_watchdog.c hal_stm32_canfifo_hid.c hal_stm32_can.c
  group hal-stm32f1-extra
    ./src/stm32f1/: hal_stm32_spi4encoder.c hal_stm32_i2c4hal.c
  group hal-stm32f1-utility
    ./src/stm32f1/stm32_utility/: hal_stm32_display_GLCD_SPI_STM32.c stm32_eval_i2c_ee.c
  group hal-stm32f1-board
    ./src/stm32f1/: hal_brdcfg.c
  group hal-utils
    ./src/utils/: crc16.c crc32.c hl_i2c.c
target hal.ems001 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: hal_ems001 (library)
  AfterMake: cmd.exe /C copy .\Obj\hal_ems001.lib .\lib\hal.ems001.lib
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1
  c define: STM32F10X_CL HAL_USE_ARCH_ARM HAL_BOARD_EMS001
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
target hal.ems001.lwip (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: hal_ems001_lwip (library)
  AfterMake: cmd.exe /C copy .\Obj\hal_ems001_lwip.lib .\lib\hal.ems001.lwip.lib
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1
  c define: STM32F10X_CL HAL_USE_ARCH_ARM HAL_BOARD_EMS001
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
software components: CMSIS:CORE 3.30.0
