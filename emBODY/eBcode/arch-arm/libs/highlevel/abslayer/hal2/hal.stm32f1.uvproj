# Keil uVision project hal.stm32f1.uvproj, settings and files
target hal2.mcbstm32c.lib (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: hal2.mcbstm32c (library)
  AfterMake: cmd.exe /C copy .\Obj\hal2.mcbstm32c.lib .\hal-lib\hal2.mcbstm32c.lib
  c flags: Optim=4 oTime=1 OneElfS=1
  c define: HAL_BOARD_MCBSTM32C STM32F10X_CL
  c misc: --c99
  c include: ..\hal\hal-api;..\hal\hal-src\core;..\hal\hal-src\brdcfg;..\hal\hal-src\extra\chips;..\hal\hal-src\extra\devices;..\hal\hal-src\extra\extbrds;..\hal\hal-src\extra\periphs;..\hal\hal-src\extra\utilities;..\..\..\..\..\..\..\eBcode\arch-arm\libs\lowlevel\hl-core\cmsis\api;..\..\..\..\..\..\..\eBcode\arch-arm\libs\lowlevel\hl-core\stm32f1\api
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group hl-stm32
    ../../../../../../../eBcode/arch-arm/libs/lowlevel/hl-core/stm32f1/src/: stm32f10x__misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../../../../../../../eBcode/arch-arm/libs/lowlevel/hl-core/cmsis/src/: system_stm32f10x.c
  group hal-brdcfg
    ./hal-src/brdcfg/: hal_brdcfg.c
  group hal-core
    ./hal-src/core/: hal_base.c hal_core.c hal_cpu.c hal_flash.c hal_heap.c hal_middleware_interface.c hal_sys.c
  group hal-extra-chips
    ./hal-src/extra/chips/: hal_chip_generic_ethtransceiver.c hal_chip_micrel_ks8893.c hal_chip_st_l3g4200d.c hal_chip_st_lis3dh.c hal_chip_xx_eeprom.c
  group hal-extra-devices
    ./hal-src/extra/devices/: hal_device_accelerometer.c hal_device_cantransceiver.c hal_device_display.c hal_device_eeprom.c hal_device_encoder.c hal_device_ethtransceiver.c hal_device_gyroscope.c hal_device_led.c hal_device_mux.c hal_device_switch.c hal_device_termometer.c
  group hal-extra-extbrds
    ./hal-src/extra/extbrds/: hal_extbrd_keil_mcbqvga.c
  group hal-extra-periphs
    ./hal-src/extra/periphs/: hal_periph_can.c hal_periph_crc.c hal_periph_dma.c hal_periph_eth.c hal_periph_gpio.c hal_periph_i2c.c hal_periph_spi.c hal_periph_timer.c hal_periph_trace.c hal_periph_uniqueid.c hal_periph_watchdog.c
  group hal-extra-utilities
    ./hal-src/extra/utilities/: hal_utility_bits.c hal_utility_crc07.c hal_utility_crc16.c hal_utility_crc32.c hal_utility_fifo.c
target hal2.ems001.lib (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: hal2.ems001 (library)
  AfterMake: cmd.exe /C copy .\Obj\hal2.ems001.lib .\hal-lib\hal2.ems001.lib
  c flags: Optim=4 oTime=1 OneElfS=1
  c define: HAL_BOARD_EMS001
  c misc: --c99
  c include: ..\hal\hal-api;..\..\..\..\sys\mid\api;..\..\..\..\sys\mid\inc;..\hal\hal-src\core;..\hal\hal-src\brdcfg;..\hal\hal-src\extra\chips;..\hal\hal-src\extra\devices;..\hal\hal-src\extra\extbrds;..\hal\hal-src\extra\periphs;..\hal\hal-src\extra\utilities;..\..\..\..\..\arch-armcmx
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
