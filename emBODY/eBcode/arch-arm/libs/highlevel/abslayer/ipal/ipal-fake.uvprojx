# Keil uVision project ipal-fake.uvprojx, settings and files
target ipal.fake.cm4 (ARM-ADS)
  device: STM32F417IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: ipal_fake_cm4 (library)
  AfterMake: cmd.exe /C copy .\Obj\ipal_fake_cm4.lib .\lib\ipal.fake.cm4.lib
  c flags: Optim=4 oTime=1 uC99=1
  c define: IPAL_USE_ARP IPAL_USE_BASE IPAL_USE_ETH IPAL_USE_IGMP IPAL_USE_SYS IPAL_USE_UDP
  c include: ..\ipal\api;.\src\fake
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group ipal-fake
    ./src/fake/: ipal_f_arp.c ipal_f_base.c ipal_f_eth.c ipal_f_igmp.c ipal_f_sys.c ipal_f_udp.c
software components: CMSIS:CORE 3.30.0
