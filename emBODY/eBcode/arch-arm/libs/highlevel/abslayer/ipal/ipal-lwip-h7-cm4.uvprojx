# Keil uVision project ipal-lwip-h7-cm4.uvprojx, settings and files
target SYS (6160000::V6.16::ARMCLANG)
  device: STM32H745XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x38000000,0x00010000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) XRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: ipal_lwip_sys (library)
  AfterMake: D:\progetti\IIT_MANO_ARTIFICALE\IPALLW\IPAL\trunk\ipal\prj\scripts\libcp_sys.bat
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: IPAL_MEMORY_MEDIUM, noFRAME_QUEUE, IPAL_USE_RTOS_FULL
  c include: ..\ipal_api;.\src\lwipcm7\ipal_src;.\src\lwipcm7\eth_interface;.\src\lwipcm7\lwip\2.1.2\lwip\src\include;.\src\lwipcm7\lwip\2.1.2\ports\cmsis-rtos\include;.\src\lwipcm7\lwip\2.1.2\rte\include;.\src\lwipcm7\lwip\2.1.2\lwip\src\netif;.\src\lwipcm7\lwip\2.1.2\ports\cmsis-driver\netif;.\src\lwipcm7\lwip_config;.\src\lwipcm7\rtos;.\src\lwipcm7\rtos\include;.\src\lwipcm7\ipal_src\extra;.\src\lwipcm7\ipal_src\debug
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT9: RAM 0x38000000 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group ipal_kernel
    ./src/lwipcm7/ipal_src/: ipal_base.c ipal_sys.c ipal_eth.c
  group ipal_services
    ./src/lwipcm7/ipal_src/: ipal_arp.c ipal_igmp.c ipal_udp.c
  group ipal_extra
    ./src/lwipcm7/ipal_src/extra/: lwip_frame_queue_handler.c lwip_tx_frame_queue_handler.c
  group ipal_debug
    ./src/lwipcm7/ipal_src/debug/: ipal_debug.c
  group eth_interface
    ./src/lwipcm7/eth_interface/: ethernetif_ipal.c ethernetif_use_ipal.c
  group lwip
    ./src/lwipcm7/lwip/2.1.2/lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ./src/lwipcm7/lwip/2.1.2/lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ./src/lwipcm7/lwip/2.1.2/lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ./src/lwipcm7/lwip/2.1.2/lwip/src/netif/: ethernet.c
  group rtos
    ./src/lwipcm7/rtos/: ipal_rtos.h ipal_rtos.c ipal_lightweight_protect.c
    ./src/lwipcm7/rtos/include/arch/: sys_arch.h
  group lwip_config
    ./src/lwipcm7/lwip_config/: lwipopts.h
target SYS_FQ (6160000::V6.16::ARMCLANG)
  device: STM32H745XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: as above
  output: ipal_lwip_sys_fq (library)
  AfterMake: D:\progetti\IIT_MANO_ARTIFICALE\IPALLW\IPAL\trunk\ipal\prj\scripts\libcp_sys_fq.bat
  c flags: Optim=5 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: IPAL_MEMORY_MEDIUM, FRAME_QUEUE, LWIP_SUPPORT_CUSTOM_PBUF, IPAL_USE_RTOS_FULL
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT9: RAM 0x38000000 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x80000
target SYS_MINIMAL (6190000::V6.19::ARMCLANG)
  device: STM32H745XIHx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x10000000,0x00048000) IROM(0x08100000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ipal_lwip_sys_minimal_cm4 (library)
  AfterMake: .\scripts\libcp_sys_minimal_cm4.bat
  c flags: Optim=6 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: IPAL_MEMORY_MEDIUM, notFRAME_QUEUE, IPAL_USE_RTOS_MINIMAL
  c include: .\api;.\src\lwipcm7\ipal_src;.\src\lwipcm7\eth_interface;.\src\lwipcm7\lwip\2.1.2\lwip\src\include;.\src\lwipcm7\lwip\2.1.2\ports\cmsis-rtos\include;.\src\lwipcm7\lwip\2.1.2\rte\include;.\src\lwipcm7\lwip\2.1.2\lwip\src\netif;.\src\lwipcm7\lwip\2.1.2\ports\cmsis-driver\netif;.\src\lwipcm7\lwip_config;.\src\lwipcm7\rtos;.\src\lwipcm7\rtos\include;.\src\lwipcm7\ipal_src\extra;.\src\lwipcm7\ipal_src\debug
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x48000
target SYS_MINIMAL_FQ (6160000::V6.16::ARMCLANG)
  device: STM32H745XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: as above
  output: ipal_lwip_sys_minimal_fq (library)
  AfterMake: D:\progetti\IIT_MANO_ARTIFICALE\IPALLW\IPAL\trunk\ipal\prj\scripts\libcp_sys_minimal_fq.bat
  c flags: Optim=5 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: IPAL_MEMORY_MEDIUM, FRAME_QUEUE, LWIP_SUPPORT_CUSTOM_PBUF, IPAL_USE_RTOS_MINIMAL
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT9: RAM 0x38000000 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x80000
