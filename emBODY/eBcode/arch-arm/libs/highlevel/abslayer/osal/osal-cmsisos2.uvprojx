# Keil uVision project osal-cmsisos2.uvprojx, settings and files
target osal.cmsisos2 (6160000::V6.16::ARMCLANG)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: osal_cmsisos2 (library)
  AfterMake: cmd.exe /C copy .\Obj\osal_cmsisos2.lib .\lib\osal.cmsisos2.lib
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=8 wLevel=1
  c misc: -DOSAL_USE_rtos_cmsisos2 -DOSAL_CPUFAM_CM4 -DEMBOT_USE_rtos_cmsisos2
  c include: .\api;..\cmsisos2\api;..\..\..\..\embot\os;..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core
  asm misc: --no_hide_all
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group osal
    ./src/: osal-cmsisos2.c
  group cmsisos2
    ../cmsisos2/lib/: cmsisos2.lib
  group embot::rtos
    ../../../../embot/os/: embot_os_rtos.cpp
  group embot::core
    ../../../../../../../../icub-firmware-shared/embot/core/: embot_core_binary.cpp embot_core.cpp
target osal.cm4.dbg (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: osal_cm4_dbg (library)
  AfterMake: cmd.exe /C copy .\Obj\osal_cm4_dbg.lib .\lib\osal.cm4.dbg.lib
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: OOSIIT_USE_EXTERNAL_TREADSAFETY OSAL_CPUFAM_CM4 __CORTEX_M4F __FPU_PRESENT=1 OOSIIT_DBG_ENABLE OOSIIT_USE_TIMEGET_UNDER_SVC
  c misc: --diag_suppress 3731
  c include: .\api;..\..\..\midware\oosiit\api;..\..\..\midware\oosiit\src\cmsis-rtx-modified\cm;..\..\..\midware\oosiit\src\others;..\..\..\midware\eventviewer;..\..\..\lowlevel\hl-core\cmsis\api
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
