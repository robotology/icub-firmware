# Keil uVision project lwip.uvprojx, settings and files
target lwip-cm7 (6240000::V6.24::ARMCLANG)
  device: STM32H747AIIx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) XRAM(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: lwipcm7 (library)
  AfterMake: cmd.exe /C copy .\tmp\cm7\obj\lwipcm7.lib ..\lib\lwip.6udp.9pkt.cm7.lib
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_AMCMJ1_1CM7 STM32HAL_DRIVER_V1B6 STM32H747xx
  c include: ..\api;..\cfg;..\LwIP\src\include;..\LwIP\system
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  link misc: --diag_suppress=L6329
  group lwip-api
    ../LwIP/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip-core
    ../LwIP/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lwip-core-ipv4
    ../LwIP/src/core/ipv4/: acd.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group lwip-netif
    ../LwIP/src/netif/: ethernet.c
target lwip-cm4 (6240000::V6.24::ARMCLANG)
  device: STM32H747AIIx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.0
  cpu: IRAM(0x10000000,0x00048000) IROM(0x08100000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lwipcm4 (library)
  AfterMake: cmd.exe /C copy .\tmp\cm4\obj\lwipcm4.lib ..\lib\lwip.6udp.9pkt.cm4.lib
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_AMCMJ1_2CM4 STM32HAL_DRIVER_V1B6 STM32H747xx
  c include: ..\api;..\cfg;..\LwIP\src\include;..\LwIP\system
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x48000
  link misc: --diag_suppress=L6329
target lwip-cm7-8udp-tx8k (6240000::V6.24::ARMCLANG)
  device: STM32H747AIIx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.0
  cpu: as above
  output: lwipcm7 (library)
  AfterMake: cmd.exe /C copy .\tmp\cm7-8udp-tx8k\obj\lwipcm7.lib ..\lib\lwip.8udp.tx8k.cm7.lib
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_AMCMJ1_1CM7 STM32HAL_DRIVER_V1B6 STM32H747xx MEMP_NUM_UDP_PCB=8 MEM_SIZE=8192 PBUF_POOL_SIZE=2
  c include: ..\api;..\cfg;..\LwIP\src\include;..\LwIP\system
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  link misc: --diag_suppress=L6329
target lwip-cm4-8udp-tx8k (6240000::V6.24::ARMCLANG)
  device: STM32H747AIIx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.0
  cpu: as above
  output: lwipcm4 (library)
  AfterMake: cmd.exe /C copy .\tmp\cm4-8udp-tx8k\obj\lwipcm4.lib ..\lib\lwip.8udp.tx8k.cm4.lib
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_AMCMJ1_2CM4 STM32HAL_DRIVER_V1B6 STM32H747xx MEMP_NUM_UDP_PCB=8 MEM_SIZE=8192 PBUF_POOL_SIZE=2
  c include: ..\api;..\cfg;..\LwIP\src\include;..\LwIP\system
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x48000
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 6.2.0
