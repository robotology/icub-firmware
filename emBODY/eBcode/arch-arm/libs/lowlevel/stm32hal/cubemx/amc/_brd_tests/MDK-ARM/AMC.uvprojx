# Keil uVision project AMC.uvprojx, settings and files
target AMC_CM4 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H745IIKx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.8.0
  cpu: IRAM(0x10000000,0x00048000) IROM(0x08100000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AMC_CM4 +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CORE_CM4,USE_HAL_DRIVER,STM32H745xx
  c include: ../CM4/Core/Inc;                                                                                              ../CM4/App/inc;                                                                                             ../Drivers/STM32H7xx_HAL_Driver/Inc;                                                                                             ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;                                                                                             ../Middlewares/Third_Party/FreeRTOS/Source/include;                                                                                             ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;                                                                                             ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;                                                                                             ../Drivers/CMSIS/Device/ST/STM32H7xx/Include;                                                                                             ../Drivers/CMSIS/Include;                                                                ../Common/Inc;                                                                ../Utilities/ResourcesManager
  asm include: ..\CM4\Core\Inc
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x48000
  scatter file: stm32h745xx_flash_CM4.sct
  group App/User/CM7/Sources
    ../CM7/App/src/: TestCM7.c usbd_vcom.c eth.c phy.c adc.c eeprom.c can.c
  group Application/User/CM7/Core
    ../CM7/Core/Src/: main.c resmgr_utility.c freertos.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Application/User/CM7/USB_DEVICE/Target
    ../CM7/USB_DEVICE/Target/: usbd_conf.c
  group Application/User/CM7/USB_DEVICE/App
    ../CM7/USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group App/User/CM4/Sources
    ../CM4/App/src/: TestCM4.c pwm.c adcm.c enc.c hall.c
  group Application/User/CM4/Core
    ../CM4/Core/Src/: main.c resmgr_utility.c freertos.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Application/User/Common/Sources
    ../Common/Src/: shared.c hwsemphr.c console.c led.c utilities.c
  group Application/MDK-ARM
    ./: startup_stm32h745xx_CM7.s startup_stm32h745xx_CM4.s
  group Drivers/CMSIS
    ../Common/Src/: system_stm32h7xx_dualcore_boot_cm4_cm7.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_rng.c stm32h7xx_hal_rng_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Linker
    ./: stm32h745xx_flash_CM4.sct stm32h745xx_flash_CM7.sct
  group Utilities
    ../Utilities/ResourcesManager/: res_mgr.c
  group Outputs
    ./AMC_CM7/: AMC_CM7.map
    ./AMC_CM4/: AMC_CM4.map
target AMC_CM7 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H745IIKx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.8.0
  cpu: IRAM(0x38000000,0x00010000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) XRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: AMC_CM7 +hex
  c flags: Optim=3 oTime=1 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_CM7,USE_HAL_DRIVER,STM32H745xx
  c include: ../CM7/Core/Inc;                                                                                              ../CM7/App/inc;                                                                                              ../CM7/USB_DEVICE/App;                                                                                              ../CM7/USB_DEVICE/Target;                                                                                             ../Drivers/STM32H7xx_HAL_Driver/Inc;                                                                                             ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;                                                                                             ../Middlewares/Third_Party/FreeRTOS/Source/include;                                                                                             ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;                                                                                             ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;                                                                                             ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;                                                                                             ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;                                                                                             ../Drivers/CMSIS/Device/ST/STM32H7xx/Include;                                                                                             ../Drivers/CMSIS/Include;                                                                ../Common/Inc;                                                                ../Utilities/ResourcesManager
  asm include: ..\CM7\Core\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT9: RAM 0x24000000 size 0x80000
  scatter file: stm32h745xx_flash_CM7.sct
software components: CMSIS:CORE 5.4.0
