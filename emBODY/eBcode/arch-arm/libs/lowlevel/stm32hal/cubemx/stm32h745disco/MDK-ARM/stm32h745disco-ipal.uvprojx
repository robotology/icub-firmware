# Keil uVision project stm32h745disco-ipal.uvprojx, settings and files
target stm32h745disco_CM4 (ARM-ADS)
  device: STM32H745XIHx:CM4 STMicroelectronics
  cpu: IRAM(0x10000000-0x10047FFF) IRAM2(0x18000000-0x1800FFFF) IROM(0x8100000-0x81FFFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M4")
  output: stm32h745disco_CM4 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_CM4,USE_HAL_DRIVER,STM32H745xx
  c include: ../CM4/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x48000
  memory RVCT10: RAM 0x18000000 size 0x10000
  scatter file: stm32h745xx_flash_CM4.sct
  group Application/MDK-ARM
    ./: startup_stm32h745xx_CM7.s startup_stm32h745xx_CM4.s
    ./: startup_stm32h745xx_CM7_ipal.s
  group Application/User/CM4
    ../CM4/Src/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Application/User/CM7
    ../CM7/Src/: main-ipal.c gpio.c eth.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Common/Src/: system_stm32h7xx_dualcore_boot_cm4_cm7.c
  group ipal
    ../../../../../../board/stm32h745disco/examples/ipal-lwip/ipal/lib/: ipal_lwip_sys_minimal.lib
  group ipal-config
    ../../../../../../board/stm32h745disco/examples/udpdemobasic/cfg/: ipal_app_cfg.c ipal_lightweight_protect.c
  group ipal-hw-driver
    ../../../../../../board/stm32h745disco/examples/udpdemobasic/drv/: ipal_hal_eth_stm32h7.c stm32h7xx_ethirqhandler.c
  group eth-cmsis-driver
    ../../../../../../board/stm32h745disco/examples/ipal-lwip/cmsis/driver/: EMAC_STM32H7xx.c PHY_LAN8740A.c
target stm32h745disco_CM7 (6160000::V6.16::ARMCLANG)
  device: STM32H745XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x00000000-0xFFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: stm32h745disco_CM7
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CORE_CM7,USE_HAL_DRIVER,STM32H745xx
  c misc: -DCUBEMXIPALDEMO -DmodifiedCMSISETH -DUSE_PC104_ADDRESSING -DAC6 -DIPAL_USE_RTOS_MINIMAL
  c include: ../CM7/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../start_of_new_include_paths;..\..\..\..\..\..\board\stm32h745disco\examples\ipal-lwip\ipal\ipal_api;..\..\..\..\..\..\board\stm32h745disco\examples\udpdemobasic\drv;..\..\..\..\..\..\board\stm32h745disco\examples\ipal-lwip\cmsis\driver;..\..\..\..\..\..\board\stm32h745disco\examples\ipal-lwip\ipal\eth_interface;..\..\..\..\..\..\board\stm32h745disco\examples\ipal-lwip\ipal\rtos;..\..\..\..\..\..\board\stm32h745disco\examples\ipal-lwip\ipal\rtos\include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: .\stm32h7disco_ipal_lwip_keil_ac5_stm32hal-full.sct
software components: CMSIS:CORE 5.4.0
