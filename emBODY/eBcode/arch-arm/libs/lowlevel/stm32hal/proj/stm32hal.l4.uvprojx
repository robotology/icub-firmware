# Keil uVision project stm32hal.l4.uvprojx, settings and files
target nucleo64-v172 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: stm32hal_nucleo64_v172 (library)
  AfterMake: cmd.exe /C copy .\obj\stm32hal_nucleo64_v172.lib ..\lib\stm32hal.nucleo64.v172.lib
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: USE_STM32HAL STM32HAL_BOARD_NUCLEO64 STM32HAL_DRIVER_V172
  c misc: --c99
  c include: ..\api;..\src\driver\stm32l4-v172\inc;..\src\board\nucleo64\v172\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --diag_suppress=L6329
  group stm32hal
    ../src/stm32hal/: stm32hal.c
  group driver-stm32l4-v172
    ../src/driver/stm32l4-v172/src/: system_stm32l4xx.c stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_can.c stm32l4xx_hal_comp.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_cryp.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_dac.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dma.c stm32l4xx_hal_firewall.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_hcd.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_irda.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_lcd.c stm32l4xx_hal_lptim.c stm32l4xx_hal_nand.c stm32l4xx_hal_nor.c stm32l4xx_hal_opamp.c stm32l4xx_hal_opamp_ex.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_sai.c stm32l4xx_hal_sd.c stm32l4xx_hal_smartcard.c stm32l4xx_hal_smartcard_ex.c stm32l4xx_hal_smbus.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_sram.c stm32l4xx_hal_swpmi.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_tsc.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_wwdg.c
  group driver-stm32l4-v183
    ../src/driver/stm32l4-v183/src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_can.c stm32l4xx_hal_comp.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_cryp.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_dac.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_dcmi.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dfsdm_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_dma2d.c stm32l4xx_hal_dsi.c stm32l4xx_hal_firewall.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gfxmmu.c stm32l4xx_hal_gpio.c stm32l4xx_hal_hash.c stm32l4xx_hal_hash_ex.c stm32l4xx_hal_hcd.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_irda.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_lcd.c stm32l4xx_hal_lptim.c stm32l4xx_hal_ltdc.c stm32l4xx_hal_ltdc_ex.c stm32l4xx_hal_nand.c stm32l4xx_hal_nor.c stm32l4xx_hal_opamp.c stm32l4xx_hal_opamp_ex.c stm32l4xx_hal_ospi.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_sai.c stm32l4xx_hal_sai_ex.c stm32l4xx_hal_sd.c stm32l4xx_hal_sd_ex.c stm32l4xx_hal_smartcard.c stm32l4xx_hal_smartcard_ex.c stm32l4xx_hal_smbus.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_sram.c stm32l4xx_hal_swpmi.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_tsc.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_wwdg.c system_stm32l4xx.c stm32l4xx_ll_usb.c
  group driver-stm32l4-v190
    ../src/driver/stm32l4-v190/src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_can.c stm32l4xx_hal_comp.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_cryp.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_dac.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_dcmi.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dfsdm_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_dma2d.c stm32l4xx_hal_dsi.c stm32l4xx_hal_exti.c stm32l4xx_hal_firewall.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gfxmmu.c stm32l4xx_hal_gpio.c stm32l4xx_hal_hash.c stm32l4xx_hal_hash_ex.c stm32l4xx_hal_hcd.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_irda.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_lcd.c stm32l4xx_hal_lptim.c stm32l4xx_hal_ltdc.c stm32l4xx_hal_ltdc_ex.c stm32l4xx_hal_nand.c stm32l4xx_hal_nor.c stm32l4xx_hal_opamp.c stm32l4xx_hal_opamp_ex.c stm32l4xx_hal_ospi.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_sai.c stm32l4xx_hal_sai_ex.c stm32l4xx_hal_sd.c stm32l4xx_hal_sd_ex.c stm32l4xx_hal_smartcard.c stm32l4xx_hal_smartcard_ex.c stm32l4xx_hal_smbus.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_sram.c stm32l4xx_hal_swpmi.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_tsc.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_wwdg.c stm32l4xx_ll_adc.c stm32l4xx_ll_comp.c stm32l4xx_ll_crc.c stm32l4xx_ll_crs.c stm32l4xx_ll_dac.c stm32l4xx_ll_dma.c stm32l4xx_ll_dma2d.c stm32l4xx_ll_exti.c stm32l4xx_ll_fmc.c stm32l4xx_ll_gpio.c stm32l4xx_ll_i2c.c stm32l4xx_ll_lptim.c stm32l4xx_ll_lpuart.c stm32l4xx_ll_opamp.c stm32l4xx_ll_pwr.c stm32l4xx_ll_rcc.c stm32l4xx_ll_rng.c stm32l4xx_ll_rtc.c stm32l4xx_ll_sdmmc.c stm32l4xx_ll_spi.c stm32l4xx_ll_swpmi.c stm32l4xx_ll_tim.c stm32l4xx_ll_usart.c stm32l4xx_ll_usb.c stm32l4xx_ll_utils.c system_stm32l4xx.c
  group driver-stm32l4-v1B0
    ../src/driver/stm32l4-v1B0/src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_can.c stm32l4xx_hal_comp.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_cryp.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_dac.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_dcmi.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dfsdm_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_dma2d.c stm32l4xx_hal_dsi.c stm32l4xx_hal_exti.c stm32l4xx_hal_firewall.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gfxmmu.c stm32l4xx_hal_gpio.c stm32l4xx_hal_hash.c stm32l4xx_hal_hash_ex.c stm32l4xx_hal_hcd.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_irda.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_lcd.c stm32l4xx_hal_lptim.c stm32l4xx_hal_ltdc.c stm32l4xx_hal_ltdc_ex.c stm32l4xx_hal_mmc.c stm32l4xx_hal_mmc_ex.c stm32l4xx_hal_nand.c stm32l4xx_hal_nor.c stm32l4xx_hal_opamp.c stm32l4xx_hal_opamp_ex.c stm32l4xx_hal_ospi.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pka.c stm32l4xx_hal_pssi.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_rng_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_sai.c stm32l4xx_hal_sai_ex.c stm32l4xx_hal_sd.c stm32l4xx_hal_sd_ex.c stm32l4xx_hal_smartcard.c stm32l4xx_hal_smartcard_ex.c stm32l4xx_hal_smbus.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_sram.c stm32l4xx_hal_swpmi.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_tsc.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_wwdg.c stm32l4xx_ll_adc.c stm32l4xx_ll_comp.c stm32l4xx_ll_crc.c stm32l4xx_ll_crs.c stm32l4xx_ll_dac.c stm32l4xx_ll_dma.c stm32l4xx_ll_dma2d.c stm32l4xx_ll_exti.c stm32l4xx_ll_fmc.c stm32l4xx_ll_gpio.c stm32l4xx_ll_i2c.c stm32l4xx_ll_lptim.c stm32l4xx_ll_lpuart.c stm32l4xx_ll_opamp.c stm32l4xx_ll_pka.c stm32l4xx_ll_pwr.c stm32l4xx_ll_rcc.c stm32l4xx_ll_rng.c stm32l4xx_ll_rtc.c stm32l4xx_ll_sdmmc.c stm32l4xx_ll_spi.c stm32l4xx_ll_swpmi.c stm32l4xx_ll_tim.c stm32l4xx_ll_usart.c stm32l4xx_ll_usb.c stm32l4xx_ll_utils.c system_stm32l4xx.c
  group driver-stm32l4-v1D2
    ../src/driver/stm32l4-v1D2/src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_can.c stm32l4xx_hal_comp.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_cryp.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_dac.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_dcmi.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dfsdm_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_dma2d.c stm32l4xx_hal_dsi.c stm32l4xx_hal_exti.c stm32l4xx_hal_firewall.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gfxmmu.c stm32l4xx_hal_gpio.c stm32l4xx_hal_hash.c stm32l4xx_hal_hash_ex.c stm32l4xx_hal_hcd.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_irda.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_lcd.c stm32l4xx_hal_lptim.c stm32l4xx_hal_ltdc.c stm32l4xx_hal_ltdc_ex.c stm32l4xx_hal_mmc.c stm32l4xx_hal_mmc_ex.c stm32l4xx_hal_nand.c stm32l4xx_hal_nor.c stm32l4xx_hal_opamp.c stm32l4xx_hal_opamp_ex.c stm32l4xx_hal_ospi.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pka.c stm32l4xx_hal_pssi.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_rng_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_sai.c stm32l4xx_hal_sai_ex.c stm32l4xx_hal_sd.c stm32l4xx_hal_sd_ex.c stm32l4xx_hal_smartcard.c stm32l4xx_hal_smartcard_ex.c stm32l4xx_hal_smbus.c stm32l4xx_hal_smbus_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_sram.c stm32l4xx_hal_swpmi.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_tsc.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_wwdg.c stm32l4xx_ll_adc.c stm32l4xx_ll_comp.c stm32l4xx_ll_crc.c stm32l4xx_ll_crs.c stm32l4xx_ll_dac.c stm32l4xx_ll_dma.c stm32l4xx_ll_dma2d.c stm32l4xx_ll_exti.c stm32l4xx_ll_fmc.c stm32l4xx_ll_gpio.c stm32l4xx_ll_i2c.c stm32l4xx_ll_lptim.c stm32l4xx_ll_lpuart.c stm32l4xx_ll_opamp.c stm32l4xx_ll_pka.c stm32l4xx_ll_pwr.c stm32l4xx_ll_rcc.c stm32l4xx_ll_rng.c stm32l4xx_ll_rtc.c stm32l4xx_ll_sdmmc.c stm32l4xx_ll_spi.c stm32l4xx_ll_swpmi.c stm32l4xx_ll_tim.c stm32l4xx_ll_usart.c stm32l4xx_ll_usb.c stm32l4xx_ll_utils.c system_stm32l4xx.c
  group board-nucleo64-v172
    ../src/board/nucleo64/v172/src/: gpio.c stm32l4xx_hal_msp.c usart.c board_nucleo64.c
  group board-nucleo64-v1D2
    ../src/board/nucleo64/v1D2/src/: board_nucleo64_v1D2.c gpio.c stm32l4xx_hal_msp.c rng.c
  group board-mtb4-v172
    ../src/board/mtb4/v172/src/: adc.c can.c dma.c gpio.c i2c.c rng.c stm32l4xx_hal_msp.c tim.c usart.c board_mtb4.c
  group board-mtb4-v190
    ../src/board/mtb4/v190/src/: adc.c board_mtb4_v190.c can.c dma.c gpio.c i2c.c rng.c stm32l4xx_hal_msp.c tim.c usart.c
  group board-rfe-v183
    ../src/board/rfe/v183/src/: adc.c can.c dma.c gpio.c i2c.c rng.c spi.c stm32l4xx_hal_msp.c tim.c board_rfe.c
  group board-strain2-v172
    ../src/board/strain2/v172/src/: adc.c can.c dma.c gpio.c i2c.c rng.c stm32l4xx_hal_msp.c tim.c usart.c board_strain2.c
  group board-strain2-v190
    ../src/board/strain2/v190/src/: adc.c can.c dma.c gpio.c i2c.c rng.c stm32l4xx_hal_msp.c tim.c usart.c board_strain2_v190.c
  group board-strain2-v1B0
    ../src/board/strain2/v1B0/src/: adc.c board_strain2_v1B0.c can.c dma.c gpio.c i2c.c rng.c stm32l4xx_hal_msp.c tim.c usart.c
  group board-psc-v190
    ../src/board/psc/v190/src/: can.c dma.c gpio.c i2c.c rng.c stm32l4xx_hal_msp.c tim.c board_psc_v190.c
  group board-sg3-v190
    ../src/board/sg3/v190/src/: adc.c board_sg3_v190.c can.c dma.c gpio.c i2c.c stm32l4xx_hal_msp.c tim.c
  group board-mtb4c-v190
    ../src/board/mtb4c/v190/src/: board_mtb4c_v190.c can.c dma.c gpio.c i2c.c stm32l4xx_hal_msp.c tim.c usart.c
target mtb4-v172 (6140000::V6.14::ARMCLANG)
  device: STM32L443RCIx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32hal_mtb4_v172 (library)
  AfterMake: cmd.exe /C copy .\v6-obj\stm32hal_mtb4_v172.lib ..\lib\stm32hal.mtb4.v172.lib
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=6 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_MTB4 STM32HAL_DRIVER_V172
  c include: ..\api;..\src\driver\stm32l4-v172\inc;..\src\board\mtb4\v172\\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
target rfe-v183 (6180000::V6.18::ARMCLANG)
  device: STM32L452CEUx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32hal_rfe_v183 (library)
  AfterMake: cmd.exe /C copy .\v6-obj\stm32hal_rfe_v183.lib ..\lib\stm32hal.rfe.v183.lib
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=6 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_RFE STM32HAL_DRIVER_V183
  c include: ..\api;..\src\driver\stm32l4-v183\inc;..\src\board\rfe\v183\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --diag_suppress=L6329
target strain2-v172 (6180000::V6.18::ARMCLANG)
  device: STM32L443RCIx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: as above
  output: stm32hal_strain2_v172 (library)
  AfterMake: cmd.exe /C copy .\v6-obj\stm32hal_strain2_v172.lib ..\lib\stm32hal.strain2.v172.lib
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=6 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_STRAIN2 STM32HAL_DRIVER_V172
  c include: ..\api;..\src\driver\stm32l4-v172\inc;..\src\board\strain2\v172\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
target mtb4-v190 (6180000::V6.18::ARMCLANG)
  device: STM32L443RCIx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: as above
  output: stm32hal_mtb4_v190 (library)
  AfterMake: cmd.exe /C copy .\v6-obj\stm32hal_mtb4_v190.lib ..\lib\stm32hal.mtb4.v190.lib
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=6 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_MTB4 STM32HAL_DRIVER_V190
  c include: ..\api;..\src\driver\stm32l4-v190\inc;..\src\board\mtb4\v190\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
target strain2-v190 (6180000::V6.18::ARMCLANG)
  device: STM32L443RCIx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: as above
  output: stm32hal_strain2_v190 (library)
  AfterMake: cmd.exe /C copy .\v6-obj\stm32hal_strain2_v190.lib ..\lib\stm32hal.strain2.v190.lib
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=6 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_STRAIN2 STM32HAL_DRIVER_V190
  c include: ..\api;..\src\driver\stm32l4-v190\inc;..\src\board\strain2\v190\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
target psc-v190 (6180000::V6.18::ARMCLANG)
  device: STM32L431KCUx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00004000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32hal_psc_v190 (library)
  AfterMake: cmd.exe /C copy .\v6-obj\stm32hal_psc_v190.lib ..\lib\stm32hal.psc.v190.lib
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=6 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_PSC STM32HAL_DRIVER_V190
  c include: ..\api;..\src\driver\stm32l4-v190\inc;..\src\board\psc\v190\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x10000000 size 0x4000
  link misc: --diag_suppress=L6329
target sg3-v190 (6140000::V6.14::ARMCLANG)
  device: STM32L431KCUx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: as above
  output: stm32hal_sg3_v190 (library)
  AfterMake: cmd.exe /C copy .\v6-obj\stm32hal_sg3_v190.lib ..\lib\stm32hal.sg3.v190.lib
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=6 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_SG3 STM32HAL_DRIVER_V190
  c include: ..\api;..\src\driver\stm32l4-v190\inc;..\src\board\sg3\v190\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
target strain2-v1B0 (6180000::V6.18::ARMCLANG)
  device: STM32L443RCIx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: as above
  output: stm32hal_strain2_v1B0 (library)
  AfterMake: cmd.exe /C copy .\v6-obj\stm32hal_strain2_v1B0.lib ..\lib\stm32hal.strain2.v1B0.lib
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=6 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_STRAIN2 STM32HAL_DRIVER_V1B0
  c include: ..\api;..\src\driver\stm32l4-v1B0\inc;..\src\board\strain2\v1B0\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
target nucleo64-v1D2 (6180000::V6.18::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: as above
  output: stm32hal_nucleo64_v1d2 (library)
  AfterMake: cmd.exe /C copy .\obj\stm32hal_nucleo64_v1D2.lib ..\lib\stm32hal.l4.nucleo64.v1D2.lib
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_NUCLEO64 STM32HAL_DRIVER_V1D2
  c include: ..\api;..\src\driver\stm32l4-v1D2\inc;..\src\board\nucleo64\v1D2\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --diag_suppress=L6329
target mtb4c-v190 (6180000::V6.18::ARMCLANG)
  device: STM32L452RCIx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: stm32hal_mtb4c_v190 (library)
  AfterMake: cmd.exe /C copy .\v6-obj\stm32hal_mtb4c_v190.lib ..\lib\stm32hal.mtb4c.v190.lib
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=6 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_MTB4C STM32HAL_DRIVER_V190
  c include: ..\api;..\src\driver\stm32l4-v190\inc;..\src\board\mtb4c\v190\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 5.6.0
