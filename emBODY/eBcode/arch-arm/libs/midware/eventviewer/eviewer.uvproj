# Keil uVision project eviewer.uvproj, settings and files
target eview-cm3 (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: eventviewer.cm3 (library)
  AfterMake: cmd.exe /C copy .\Obj\eventviewer.cm3.lib .\lib\eventviewer.cm3.lib
  c flags: Optim=4 oTime=1
  c include: .\api
  scatter file: RTLFS.sct
  group eventviewer
    ./src/: eventviewer.c
target eview-cm4 (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: eventviewer.cm4 (library)
  AfterMake: cmd.exe /C copy .\Obj\eventviewer.cm4.lib .\lib\eventviewer.cm4.lib
  c flags: Optim=4 oTime=1
  c include: .\api
  scatter file: RTLFS.sct
