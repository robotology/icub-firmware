# Keil uVision project oosiit.uvproj, settings and files
target CM1_LE (ARM-ADS)
  device: Cortex-M1 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M1")
  output: RTX_CM1 (library)
  AfterMake: cmd.exe /C copy ArInp.Scr CM1_LE\BuildLib.scr
  c flags: Optim=4 OneElfS=1
  group cmsis-rtx-src-modified
    ./src/cmsis-rtx-modified/cm/: rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Memory.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
  group cmsis-rtx-cfg-modified
    ./src/cmsis-rtx-modified/cm/: HAL_CM.c HAL_CM3.c HAL_CM4.c SVC_Table.s
  group others
    ./src/others/: oosiit.c rt_iit_changes.c rt_iit_AdvTimer.c rt_iit_memory.c oosiit_storage.c
target CM1_BE (ARM-ADS)
  device: Cortex-M1 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M1") ESEL ELITTLE
  output: RTX_CM1_B (library)
  AfterMake: cmd.exe /C copy ArInp.Scr CM1_BE\BuildLib.scr
  c flags: Optim=4 OneElfS=1
target oosiit-cm3-le (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: oosiit.cm3 (library)
  AfterMake: cmd.exe /C copy .\Obj\oosiit.cm3.lib .\lib\oosiit.cm3.lib
  c flags: Optim=4 oTime=1 OneElfS=1
  c define: __CORTEX_M3 NDBG_MSG OOSIIT_USE_TIMEGET_UNDER_SVC
  c misc: --c99
  c include: .\api;.\src\cmsis-rtx-modified\cm;.\src\others
target oosiit-cm3-dbg-le (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: oosiit.cm3.dbg (library)
  AfterMake: cmd.exe /C copy .\Obj\oosiit.cm3.dbg.lib .\lib\oosiit.cm3.dbg.lib
  c flags: Optim=4 oTime=1 OneElfS=1
  c define: __CORTEX_M3 OOSIIT_DBG_ENABLE OOSIIT_USE_TIMEGET_UNDER_SVC
  c misc: --c99
  c include: .\api;.\src\cmsis-rtx-modified\cm;.\src\others;..\..\midware\eventviewer
target CM3_BE (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: RTX_CM3_B (library)
  AfterMake: cmd.exe /C copy ArInp.Scr CM3_BE\BuildLib.scr
  c flags: Optim=4 OneElfS=1
  c define: DBG_MSG
target CM3X_LE (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: RTX_CM3X (library)
  AfterMake: cmd.exe /C copy ArInp.Scr CM3X_LE\BuildLib.scr
  c flags: Optim=4 OneElfS=1
  c define: DBG_MSG NO_EXCLUSIVE_ACCESS
target oosiit-cm4-le (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: oosiit.cm4 (library)
  AfterMake: cmd.exe /C copy .\Obj\oosiit.cm4.lib .\lib\oosiit.cm4.lib
  c flags: Optim=4 oTime=1 OneElfS=1
  c define: __CORTEX_M4 __FPU_PRESENT OOSIIT_USE_TIMEGET_UNDER_SVC
  c misc: --c99
  c include: .\api;.\src\cmsis-rtx-modified\cm;.\src\others;..\..\..\..\sys\mid; ..\..\..\..\sys\mid\inc
target oosiit-cm4-dbg-le (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: oosiit.cm4.dbg (library)
  AfterMake: cmd.exe /C copy .\Obj\oosiit.cm4.dbg.lib .\lib\oosiit.cm4.dbg.lib
  c flags: Optim=4 oTime=1 OneElfS=1
  c define: __CORTEX_M4 __FPU_PRESENT OOSIIT_DBG_ENABLE OOSIIT_USE_TIMEGET_UNDER_SVC
  c misc: --c99
  c include: as above
target CM4F_BE (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: RTX_CM4_B (library)
  AfterMake: cmd.exe /C copy ArInp.Scr CM4F_BE\BuildLib.scr
  c flags: Optim=4 OneElfS=1
  c define: DBG_MSG
