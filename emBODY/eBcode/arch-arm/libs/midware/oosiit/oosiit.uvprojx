# Keil uVision project oosiit.uvprojx, settings and files
target oosiit-cm4-le (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.0.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: oosiit_cm4 (library)
  AfterMake: cmd.exe /C copy .\Obj\oosiit_cm4.lib .\lib\oosiit.cm4.lib
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __CORTEX_M4F __FPU_PRESENT=1 OOSIIT_USE_TIMEGET_UNDER_SVC
  c misc: --diag_suppress 3731
  c include: .\api;.\src\cmsis-rtx-modified\cm;.\src\others;..\..\midware\eventviewer;..\..\lowlevel\hl-core\cmsis\api
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group cmsis-rtx-src-modified
    ./src/cmsis-rtx-modified/cm/: rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Memory.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
  group cmsis-rtx-cfg-modified
    ./src/cmsis-rtx-modified/cm/: HAL_CM.c HAL_CM3.c HAL_CM4.c SVC_Table.s
  group others
    ./src/others/: rt_iit_changes.c oosiit.c rt_iit_AdvTimer.c rt_iit_memory.c oosiit_storage.c
target oosiit-cm4-dbg-le (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.0.0
  cpu: as above
  output: oosiit_cm4_dbg (library)
  AfterMake: cmd.exe /C copy .\Obj\oosiit_cm4_dbg.lib .\lib\oosiit.cm4.dbg.lib
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: __CORTEX_M4F __FPU_PRESENT=1 OOSIIT_DBG_ENABLE OOSIIT_USE_TIMEGET_UNDER_SVC
  c misc: --diag_suppress 3731
  c include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
software components: CMSIS:CORE 5.0.0
