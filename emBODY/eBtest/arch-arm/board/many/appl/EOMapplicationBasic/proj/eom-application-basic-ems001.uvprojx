# Keil uVision project eom-application-basic-ems001.uvprojx, settings and files
target mcbstm32c (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: eom-appl-basic +hex
  c flags: Optim=1 OneElfS=1
  c define: HAL_USE_ARCH_ARM
  c misc: --c99
  c include: ..\..\cfg;..\app_extra;..\app_basic;..\..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\hal\api;..\..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\..\eBcode\embobj\core\core;..\..\..\..\..\..\..\eBcode\embobj\core\exec\multitask;..\..\..\..\..\..\..\eBcode\arch-arm\libs\midware\eventviewer\api
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group application
    ../app_basic/: eom_applbasic_main.c eom_applbasic_specialise.c
  group abslayer-lib
    ../../../../../../../eBcode/arch-arm/libs/highlevel/abslayer/hal/stg/: hal_startup_stm32f107.s
    ../../../../../../../eBcode/arch-arm/libs/highlevel/abslayer/hal/lib/: hal.mcbstm32c.lib hal.ems001.lib
    ../../../../../../../eBcode/arch-arm/libs/highlevel/abslayer/osal/lib/: osal.cm3.dbg.lib
  group abslayer-cfg
    ../abslayer-cfg/: hal_cfg.c osal_cfg.c hal_cfg.h osal_cfg.h
  group eo-core
    ../../../../../../../eBcode/embobj/core/core/: EOaction.c EOarray.c EoCommon.c EOconstarray.c EOconstvector.c EOdeque.c EOfifo.c EOfifoByte.c EOfifoWord.c EOlist.c EONmutex.c EONtask.c EONtheCallbackManager.c EONtheSystem.c EONtheTimerManager.c EOpacket.c EOsm.c EOtheErrorManager.c EOtheLEDpulser.c EOtheMemoryPool.c EOtimer.c EOumlsm.c EOvector.c EOVmutex.c EOVtask.c EOVtheCallbackManager.c EOVtheSystem.c EOVtheTimerManager.c
  group eo-mee
    ../../../../../../../eBcode/embobj/core/exec/multitask/: EOMmutex.c EOMtask.c EOMtheCallbackManager.c EOMtheSystem.c EOMtheTimerManager.c
  group eventviewer
    ../../../../../../../eBcode/arch-arm/libs/midware/eventviewer/src/: eventviewer.c
target ems001 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: eom-appl-basic +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: HAL_USE_ARCH_ARM
  c include: ..\..\cfg;..\app_extra;..\app_basic;..\..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\hal\api;..\..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\ipal\api;..\..\..\..\..\..\..\eBcode\embobj\core\core;..\..\..\..\..\..\..\eBcode\embobj\core\exec\multitask;..\..\..\..\..\..\..\eBcode\embobj\plus\ipnet;..\..\..\..\..\..\..\eBcode\arch-arm\libs\midware\eventviewer\api
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
software components: CMSIS:CORE 3.30.0
