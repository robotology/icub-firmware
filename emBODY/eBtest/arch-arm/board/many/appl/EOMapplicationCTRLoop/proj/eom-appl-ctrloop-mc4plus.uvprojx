# Keil uVision project eom-appl-ctrloop-mc4plus.uvprojx, settings and files
target ctrloop-mc4plus-zero (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: emsappl4mcbstm32c +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: TOGGLE_RUN_CFG_WITH3RXPACKETS EOPROT_USE_MN_VERSION_2_0 dontEOPROT_CFG_OVERRIDE_CALLBACKS_IN_RUNTIME _FORCE_NETWORK_FROM_IPAL_CFG EENV_EAPPLICATION_FORCE_CODE_OFFSET_TO_ZERO EO_USE_EPROT_V2 HAL_IS_VERSION_2
  c misc: -DemBODYrobot_ROBOT_NAME=iCubANY -DemBODYrobot_BOARD_NAME=boardEMS4RD -DemBODYrobot_BOARD_NUMBER=boardnumberANY
  c include: ..\..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\ipal\api;..\..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\exec\multitask;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\embenv;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\ipnet;..\..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\services\embenv\api;..\..\..\..\..\..\..\eBcode\arch-arm\libs\midware\eventviewer\api;..\app_main;..\app_cfg;..\abslayer-cfg-stm32f4;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\ctrloop;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\icub;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\opcprot;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\transport;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\protocol\api;..\..\..\..\..\..\..\eBcode\arch-arm\board\ems004\appl\v1\cfg\eoprot-boards;..\embenv_cfg\ems004like;..\..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\hal2\api;..\..\..\..\..\..\..\eBcode\arch-arm\\libs\highlevel\services\embodyrobot\api;..\..\..\..\..\..\..\eBcode\arch-arm\\libs\highlevel\services\embodyrobot;..\..\..\..\..\..\..\..\..\icub-firmware-shared\can\canProtocolLib;..\..\..\..\..\..\..\eBcode\arch-arm\board\ems004\appl\v1\src\eoappservices;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\board\ems001
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg-stm32f4
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\embenv_cfg\ems004like\eApplication-zerooffset.sct
  group app_main
    ../app_main/: eom_appl_ctrloop_main.c
  group abslayer-lib
    ../../../../../../../eBcode/arch-arm/libs/highlevel/abslayer/ipal/lib/: ipal.base.medium.cm4.lib
    ../../../../../../../eBcode/arch-arm/libs/highlevel/abslayer/osal/lib/: osal.cm4.dbg.lib
    ../../../../../../../eBcode/arch-arm/libs/highlevel/abslayer/hal2/lib/: hal2.mc4plus.ethdbg.lib
  group abslayer-cfg
    ../abslayer-cfg-stm32f4/: hal_core_cfg.c hal_core_cfg.h ipal_cfg.c ipal_cfg.h osal_cfg.c osal_cfg.h hal_startup_mpu_name_stm32f407ig.s
  group eo-core
    ../../../../../../../../../icub-firmware-shared/eth/embobj/core/core/: EOpacket.c EOsm.c EOaction.c EOarray.c EoCommon.c EOconstarray.c EOconstvector.c EOdeque.c EOfifo.c EOfifoByte.c EOfifoWord.c EOlist.c EOtheErrorManager.c EOtheLEDpulser.c EOtheMemoryPool.c EOtimer.c EOumlsm.c EOvector.c EOVmutex.c EOVtask.c EOVtheCallbackManager.c EOVtheSystem.c EOVtheTimerManager.c
  group eo-mee
    ../../../../../../../../../icub-firmware-shared/eth/embobj/core/exec/multitask/: EOMmutex.c EOMtask.c EOMtheCallbackManager.c EOMtheSystem.c EOMtheTimerManager.c
  group eo-ipnet
    ../../../../../../../../../icub-firmware-shared/eth/embobj/plus/ipnet/: EOMtheIPnet.c EOsocket.c EOsocketDatagram.c EOVtheIPnet.c
  group eo-arm-env
    ../../../../../../../../../icub-firmware-shared/eth/embobj/plus/embenv/: EOtheARMenvironment.c EOVtheEnvironment.c
  group eventviewer
    ../../../../../../../eBcode/arch-arm/libs/midware/eventviewer/src/: eventviewer.c
  group arm-services-embenv
    ../../../../../../../eBcode/arch-arm/libs/highlevel/services/embenv/src/: eEcommon.c eEsharedServices.c shalBASE.c shalINFO.c shalPART.c
  group eo-ctrloop
    ../../../../../../../../../icub-firmware-shared/eth/embobj/plus/ctrloop/: eOcfg_sm_EMSappl.c EOMtheEMSappl.c EOMtheEMSapplCfg.c EOMtheEMSbackdoor.c EOMtheEMSbackdoortransceiver.c EOMtheEMSconfigurator.c EOMtheEMSdiscoverylistener.c EOMtheEMSdiscoverytransceiver.c EOMtheEMSerror.c EOMtheEMSrunner.c EOMtheEMSsocket.c EOMtheEMStransceiver.c
  group eo-ctrloop-cfg
    ../app_cfg/: EOMtheEMSapplCfg_cfg.h example_overridden_appl.c example_overridden_configurator.c example_overridden_error.c example_overridden_runner.c overridden_backdoortransceiver.c
  group app-services
    ../../../../../../../eBcode/arch-arm/board/ems004/appl/v1/src/eoappservices/: EOappEncodersReader.c
  group opc-protocol
    ../../../../../../../../../icub-firmware-shared/eth/embobj/plus/comm-v2/opcprot/: OPCprotocolManager.c
  group opc-protocol-cfg
    ../app_cfg/: OPCprotocolManager_Cfg.c
  group eo-comm-transport
    ../../../../../../../../../icub-firmware-shared/eth/embobj/plus/comm-v2/transport/: EOagent.c EOconfirmationManager.c EOnv.c EOnvSet.c EOproxy.c EOreceiver.c EOrop.c EOropframe.c EOtheBOARDtransceiver.c EOtheFormer.c EOtheParser.c EOtransceiver.c EOtransmitter.c EOtheInfoDispatcher.c
  group eo-comm-protocol
    ../../../../../../../../../icub-firmware-shared/eth/embobj/plus/comm-v2/protocol/src/: EoProtocol.c EoProtocolAS_fun.c EoProtocolAS_rom.c EoProtocolEPs.c EoProtocolMC_fun.c EoProtocolMC_rom.c EoProtocolMN_fun.c EoProtocolMN_rom.c EoProtocolSK_fun.c EoProtocolSK_rom.c
    ../../../../../../../../../icub-firmware-shared/eth/embobj/plus/comm-v2/icub/: EoError.c
  group eo-comm-protocol-cfg-boards
    ../../../../../../../eBcode/arch-arm/board/ems004/appl/v1/cfg/eoprot-boards/: eOprot_b01.c eOprot_b02.c eOprot_b03.c eOprot_b04.c eOprot_b05.c eOprot_b06.c eOprot_b07.c eOprot_b08.c eOprot_b09.c eOprot_b10.c eOprot_b11.c
  group eo-comm-protocol-cfg-callbacks
    ../app_cfg/: EoProtocolEPmn_fun_overridden.c EoProtocolEPmc_fun_overridden.c
  group embody-robot
    ../../../../../../../eBcode/arch-arm//libs/highlevel/services/embodyrobot/: emBODYrobot.c
  group nee
    ../../../../../../../../../icub-firmware-shared/eth/embobj/core/core/: EONtheSystem.c EONtheCallbackManager.c EONtheTimerManager.c EONtask.c EONmutex.c
  group eo-comm-transport-host
    ../../../../../../../../../icub-firmware-shared/eth/embobj/plus/comm-v2/transport/: EOprotocolConfigurator.c EOdeviceTransceiver.c EOhostTransceiver.c EOnvsetDEVbuilder.c
target ctrloop-mc4plus-norm (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: as above
  output: eomapplctrloop +hex
  c flags: Optim=1 uC99=1
  c define: DONT_TEST_ARP EOPROT_USE_MN_VERSION_2_0 dontEOPROT_CFG_OVERRIDE_CALLBACKS_IN_RUNTIME DONT_FORCE_NETWORK_FROM_IPAL_CFG HAL_IS_VERSION_2 dontTOGGLE_RUN_CFG_WITH3RXPACKETS
  c misc: as above
  c include: ..\..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\ipal\api;..\..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\exec\multitask;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\embenv;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\ipnet;..\..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\services\embenv\api;..\..\..\..\..\..\..\eBcode\arch-arm\libs\midware\eventviewer\api;..\app_main;..\app_cfg;..\abslayer-cfg-stm32f4;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\ctrloop;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\icub;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\opcprot;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\transport;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\protocol\api;..\..\..\..\..\..\..\eBcode\arch-arm\board\ems004\appl\v1\cfg\eoprot-boards;..\embenv_cfg\ems004like;..\..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\hal2\api;..\..\..\..\..\..\..\eBcode\arch-arm\\libs\highlevel\services\embodyrobot;..\..\..\..\..\..\..\..\..\icub-firmware-shared\can\canProtocolLib;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\board\ems001
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg-stm32f4
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\embenv_cfg\ems004like\eApplication.sct
software components: CMSIS:CORE 3.30.0
