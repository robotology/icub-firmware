# Keil uVision project eom-appl-ctrloop-old.uvproj, settings and files
target ctrloop-mcbstm32c-zerooffset (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: emsappl4mcbstm32c +hex
  c flags: Optim=1 OneElfS=1
  c define: HAL_USE_ARCH_ARM EENV_EAPPLICATION_FORCE_CODE_OFFSET_TO_ZERO
  c misc: --c99
  c include: ..\..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\hal\api;..\..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\ipal\api;..\..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\..\eBcode\embobj\core\core;..\..\..\..\..\..\..\eBcode\embobj\core\exec\multitask;..\..\..\..\..\..\..\eBcode\embobj\plus\embenv;..\..\..\..\..\..\..\eBcode\embobj\plus\ipnet;..\..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\services\embenv\api;..\..\..\..\..\..\..\eBcode\arch-arm\libs\midware\eventviewer\api;..\app_main;..\app_cfg;..\abslayer-cfg;..\..\..\..\..\..\..\eBcode\embobj\plus\ctrloop;..\..\..\..\..\..\..\eBcode\embobj\plus\comm-v1\icub;..\..\..\..\..\..\..\eBcode\embobj\plus\comm-v1\prot;..\..\..\..\..\..\..\eBcode\embobj\plus\comm-v1\nvs\board-eps;..\..\..\..\..\..\..\eBcode\embobj\plus\comm-v1\nvs\ep-analogsensors;..\..\..\..\..\..\..\eBcode\embobj\plus\comm-v1\nvs\ep-motioncontrol;..\..\..\..\..\..\..\eBcode\embobj\plus\comm-v1\nvs\ep-management;..\..\..\..\..\..\..\eBcode\embobj\plus\comm-v1\nvs\ep-skin;..\..\..\..\..\..\..\eBcode\embobj\plus\comm-v1\opcprot;..\embenv_cfg\ems001like
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\eApplication-zerooffset.sct
  group app_main
    ../app_main/: eom_appl_ctrloop_main.c
  group abslayer-lib
    ../../../../../../../eBcode/arch-arm/libs/highlevel/abslayer/hal/lib/: hal.ems001.lib hal.mcbstm32c.lib
    ../../../../../../../eBcode/arch-arm/libs/highlevel/abslayer/hal/stg/: hal_startup_stm32f107.s
    ../../../../../../../eBcode/arch-arm/libs/highlevel/abslayer/osal/lib/: osal.cm3.dbg.lib
    ../../../../../../../eBcode/arch-arm/libs/highlevel/abslayer/ipal/lib/: ipal.base.medium.lib
  group abslayer-cfg
    ../abslayer-cfg/: hal_cfg.c ipal_cfg.c osal_cfg.c hal_cfg.h ipal_cfg.h osal_cfg.h
  group eo-core
    ../../../../../../../eBcode/embobj/core/core/: EOaction.c EOarray.c EoCommon.c EOconstarray.c EOconstvector.c EOdeque.c EOfifo.c EOfifoByte.c EOfifoWord.c EOlist.c EOpacket.c EOsm.c EOtheErrorManager.c EOtheLEDpulser.c EOtheMemoryPool.c EOtimer.c EOumlsm.c EOvector.c EOVmutex.c EOVtask.c EOVtheCallbackManager.c EOVtheSystem.c EOVtheTimerManager.c
  group eo-core-mee
    ../../../../../../../eBcode/embobj/core/exec/multitask/: EOMmutex.c EOMtask.c EOMtheCallbackManager.c EOMtheSystem.c EOMtheTimerManager.c
  group eo-ipnet
    ../../../../../../../eBcode/embobj/plus/ipnet/: EOMtheIPnet.c EOsocket.c EOsocketDatagram.c EOVtheIPnet.c
  group eo-arm-env
    ../../../../../../../eBcode/embobj/plus/embenv/: EOtheARMenvironment.c EOVtheEnvironment.c
  group eventviewer
    ../../../../../../../eBcode/arch-arm/libs/midware/eventviewer/src/: eventviewer.c
  group arm-services-embenv
    ../../../../../../../eBcode/arch-arm/libs/highlevel/services/embenv/src/: eEcommon.c eEsharedServices.c shalBASE.c shalINFO.c shalPART.c
  group eo-ctrloop
    ../../../../../../../eBcode/embobj/plus/ctrloop/: eOcfg_sm_EMSappl.c EOMtheEMSappl.c EOMtheEMSapplCfg.c EOMtheEMSbackdoor.c EOMtheEMSbackdoortransceiver.c EOMtheEMSconfigurator.c EOMtheEMSdiscoverylistener.c EOMtheEMSdiscoverytransceiver.c EOMtheEMSerror.c EOMtheEMSrunner.c EOMtheEMSsocket.c EOMtheEMStransceiver.c
  group eo-ctrloop-cfg
    ../app_cfg/: EOMtheEMSapplCfg_cfg.h example_overridden_appl.c example_overridden_configurator.c example_overridden_error.c example_overridden_runner.c overridden_backdoortransceiver.c
  group opc-protocol
    ../../../../../../../eBcode/embobj/plus/comm-v1/opcprot/: OPCprotocolManager.c
  group opc-protocol-cfg
    ../app_cfg/: OPCprotocolManager_Cfg.c
  group eo-comm-prot
    ../../../../../../../eBcode/embobj/plus/comm-v1/prot/: EOconfirmationManager.c EOfakeStorage.c EOhostTransceiver.c EOmatrix3d.c EOnv.c EOnvsCfg.c EOreceiver.c EOrop.c EOropframe.c EOstorageEEPROM.c EOtheAgent.c EOtheBOARDtransceiver.c EOtheFormer.c EOtheParser.c EOtransceiver.c EOtransmitter.c EOtreenode.c EOVstorage.c
  group eo-comm-nvs-boards
    ../../../../../../../eBcode/embobj/plus/comm-v1/nvs/board-eps/: eOcfg_EPs_board.c eOcfg_EPs_eb1.c eOcfg_EPs_eb2.c eOcfg_EPs_eb3.c eOcfg_EPs_eb4.c eOcfg_EPs_eb5.c eOcfg_EPs_eb6.c eOcfg_EPs_eb7.c eOcfg_EPs_eb8.c eOcfg_EPs_eb9.c
  group eo-comm-nvs-ep-as
    ../../../../../../../eBcode/embobj/plus/comm-v1/nvs/ep-analogsensors/: eOcfg_nvsEP_as.c eOcfg_nvsEP_as_any_con_body.c eOcfg_nvsEP_as_any_con_mxx.c eOcfg_nvsEP_as_any_con_mxxdefault.c eOcfg_nvsEP_as_any_con_sxx.c eOcfg_nvsEP_as_any_con_sxxdefault.c eOcfg_nvsEP_as_onemais_con.c eOcfg_nvsEP_as_onemais_usr.c eOcfg_nvsEP_as_onestrain_con.c eOcfg_nvsEP_as_onestrain_usr.c
  group eo-comm-nvs-ep-mc
    ../../../../../../../eBcode/embobj/plus/comm-v1/nvs/ep-motioncontrol/: eOcfg_nvsEP_mc.c eOcfg_nvsEP_mc_any_con_bodypart.c eOcfg_nvsEP_mc_any_con_cxx.c eOcfg_nvsEP_mc_any_con_cxxdefault.c eOcfg_nvsEP_mc_any_con_jxx.c eOcfg_nvsEP_mc_any_con_jxxdefault.c eOcfg_nvsEP_mc_any_con_mxx.c eOcfg_nvsEP_mc_any_con_mxxdefault.c eOcfg_nvsEP_mc_lowerarm_con.c eOcfg_nvsEP_mc_lowerarm_usr.c eOcfg_nvsEP_mc_lowerleg_con.c eOcfg_nvsEP_mc_lowerleg_usr.c eOcfg_nvsEP_mc_torso_con.c eOcfg_nvsEP_mc_torso_usr.c eOcfg_nvsEP_mc_upperarm_con.c eOcfg_nvsEP_mc_upperarm_usr.c eOcfg_nvsEP_mc_upperleg_con.c eOcfg_nvsEP_mc_upperleg_usr.c
  group eo-comm-nvs-ep-mn
    ../../../../../../../eBcode/embobj/plus/comm-v1/nvs/ep-management/: eOcfg_nvsEP_mn.c eOcfg_nvsEP_mn_appl_con.c eOcfg_nvsEP_mn_appl_usr.c eOcfg_nvsEP_mn_comm_con.c eOcfg_nvsEP_mn_comm_usr.c
  group eo-comm-nvs-ep-sk
    ../../../../../../../eBcode/embobj/plus/comm-v1/nvs/ep-skin/: eOcfg_nvsEP_sk.c eOcfg_nvsEP_sk_emsboard_con.c eOcfg_nvsEP_sk_emsboard_usr.c
  group eo-comm-nvs-cfg
    ../app_cfg/: eOcfg_nvsEP_mn_comm_usrcbk_ebx.c
  group nee
    ../../../../../../../eBcode/embobj/core/core/: EONmutex.c EONtask.c EONtheCallbackManager.c EONtheSystem.c EONtheTimerManager.c
target ctrloop-mcbstm32c-normoffset (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: emsappl4mcbstm32c +hex
  c flags: Optim=1 OneElfS=1
  c define: HAL_USE_ARCH_ARM
  c misc: --c99
  c include: as above
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\eApplication.sct
target ctrloop-ems001-normoffset (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: emsappl4mcbstm32c +hex
  c flags: Optim=1
  c define: HAL_USE_ARCH_ARM
  c misc: --c99
  c include: as above
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\eApplication.sct
target ctrloop-ems001-zerooffset (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: emsappl4mcbstm32c +hex
  c flags: Optim=1
  c define: HAL_USE_ARCH_ARM EENV_EAPPLICATION_FORCE_CODE_OFFSET_TO_ZERO
  c misc: --c99
  c include: as above
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\eApplication-zerooffset.sct
