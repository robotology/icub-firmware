# Keil uVision project eom-appl-ctrloop-wip1-ems4rd.uvproj, settings and files
target ctrloop-v2-ems4-zero (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: emsappl4mcbstm32c +hex
  c flags: Optim=1
  c define: HAL_USE_ARCH_ARM EENV_EAPPLICATION_FORCE_CODE_OFFSET_TO_ZERO EO_USE_EPROT_V2 HAL_USE_VERSION_2
  c misc: --c99
  c include: ..\..\..\..\..\..\..\eBcode\arch-arm\libs\abslayer\ipal\api;..\..\..\..\..\..\..\eBcode\arch-arm\libs\abslayer\osal\api;..\..\..\..\..\..\..\eBcode\embobj\core\core;..\..\..\..\..\..\..\eBcode\embobj\core\exec\multitask;..\..\..\..\..\..\..\eBcode\embobj\plus\embenv;..\..\..\..\..\..\..\eBcode\embobj\plus\ipnet;..\..\..\..\..\..\..\eBcode\arch-arm\libs\services\embenv\api;..\..\..\..\..\..\..\eBcode\arch-arm\libs\midware\eventviewer\api;..\app_main;..\app_cfg;..\abslayer-cfg-stm32f4;..\..\..\..\..\..\..\eBcode\embobj\plus\ctrloop;..\..\..\..\..\..\..\eBcode\embobj\plus\comm-v2\icub;..\..\..\..\..\..\..\eBcode\embobj\plus\comm-v1\opcprot;..\..\..\..\..\..\..\eBcode\embobj\plus\comm-v2\transport;..\..\..\..\..\..\..\eBcode\embobj\plus\comm-v2\protocol\api;..\..\..\..\..\..\..\eBcode\robotconfig\v1\eprotocol;..\embenv_cfg\ems001like;..\..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\hal2\api
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg-stm32f4
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\embenv_cfg\ems004like\eApplication-zerooffset.sct
  group app_main
    ../app_main/: eom_appl_ctrloop_main.c
  group abslayer-lib
    ../../../../../../../eBcode/arch-arm/libs/abslayer/ipal/lib/: ipal.base.medium.cm4.lib
    ../../../../../../../eBcode/arch-arm/libs/abslayer/osal/lib/: osal.cm4.dbg.lib
    ../../../../../../../eBcode/arch-arm/libs/highlevel/abslayer/hal2/lib/: hal2.ems4rd.lib
  group abslayer-cfg
    ../abslayer-cfg-stm32f4/: hal_core_cfg.c hal_core_cfg.h ipal_cfg.c ipal_cfg.h osal_cfg.c osal_cfg.h hal_startup_mpu_name_stm32f407ig.s
  group eo-core
    ../../../../../../../eBcode/embobj/core/core/: EOpacket.c EOsm.c EOaction.c EOarray.c EoCommon.c EOconstarray.c EOconstvector.c EOdeque.c EOfifo.c EOfifoByte.c EOfifoWord.c EOlist.c EOtheErrorManager.c EOtheLEDpulser.c EOtheMemoryPool.c EOtimer.c EOumlsm.c EOvector.c EOVmutex.c EOVtask.c EOVtheCallbackManager.c EOVtheSystem.c EOVtheTimerManager.c
  group eo-mee
    ../../../../../../../eBcode/embobj/core/exec/multitask/: EOMmutex.c EOMtask.c EOMtheCallbackManager.c EOMtheSystem.c EOMtheTimerManager.c
  group eo-ipnet
    ../../../../../../../eBcode/embobj/plus/ipnet/: EOMtheIPnet.c EOsocket.c EOsocketDatagram.c EOVtheIPnet.c
  group eo-arm-env
    ../../../../../../../eBcode/embobj/plus/embenv/: EOtheARMenvironment.c EOVtheEnvironment.c
  group eventviewer
    ../../../../../../../eBcode/arch-arm/libs/midware/eventviewer/src/: eventviewer.c
  group arm-services-embenv
    ../../../../../../../eBcode/arch-arm/libs/services/embenv/src/: eEcommon.c eEsharedServices.c shalBASE.c shalINFO.c shalPART.c
  group eo-ctrloop
    ../../../../../../../eBcode/embobj/plus/ctrloop/: eOcfg_sm_EMSappl.c EOMtheEMSappl.c EOMtheEMSapplCfg.c EOMtheEMSbackdoor.c EOMtheEMSbackdoortransceiver.c EOMtheEMSconfigurator.c EOMtheEMSdiscoverylistener.c EOMtheEMSdiscoverytransceiver.c EOMtheEMSerror.c EOMtheEMSrunner.c EOMtheEMSsocket.c EOMtheEMStransceiver.c
  group eo-ctrloop-cfg
    ../app_cfg/: EOMtheEMSapplCfg_cfg.h example_overridden_appl.c example_overridden_configurator.c example_overridden_error.c example_overridden_runner.c overridden_backdoortransceiver.c
  group opc-protocol
    ../../../../../../../eBcode/embobj/plus/comm-v1/opcprot/: OPCprotocolManager.c
  group opc-protocol-cfg
    ../app_cfg/: OPCprotocolManager_Cfg.c
  group eo-comm-v2-transport
    ../../../../../../../eBcode/embobj/plus/comm-v2/transport/: EOagent.c EOconfirmationManager.c EOhostTransceiver.c EOnv.c EOnvSet.c EOproxy.c EOreceiver.c EOrop.c EOropframe.c EOtheBOARDtransceiver.c EOtheFormer.c EOtheParser.c EOtransceiver.c EOtransmitter.c
  group eo-comm-v2-protocol-boards
    ../../../../../../../eBcode/robotconfig/v1/eprotocol/: eOprot_b01.c eOprot_b02.c eOprot_b03.c eOprot_b04.c eOprot_b05.c eOprot_b06.c eOprot_b07.c eOprot_b08.c eOprot_b09.c
  group eo-comm-v2-protocol
    ../../../../../../../eBcode/embobj/plus/comm-v2/protocol/src/: EoProtocol.c EoProtocolAS_fun.c EoProtocolAS_rom.c EoProtocolEPs.c EoProtocolMC_fun.c EoProtocolMC_rom.c EoProtocolMN_fun.c EoProtocolMN_rom.c EoProtocolSK_fun.c EoProtocolSK_rom.c
  group eo-nvs-cfg-usrcbk
    ../app_cfg/: EoProtocolEPmn_fun_overridden.c EoProtocolEPmc_fun_overridden.c
  group nee
    ../../../../../../../eBcode/embobj/core/core/: EONtheSystem.c EONtheCallbackManager.c EONtheTimerManager.c EONtask.c EONmutex.c
target ctrloop-v2-ems4-norm (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: as above
  output: emsappl4mcbstm32c +hex
  c flags: Optim=1
  c define: HAL_USE_ARCH_ARM EO_USE_EPROT_V2 HAL_USE_VERSION_2
  c misc: --c99
  c include: ..\..\..\..\..\..\..\eBcode\arch-arm\libs\abslayer\ipal\api;..\..\..\..\..\..\..\eBcode\arch-arm\libs\abslayer\osal\api;..\..\..\..\..\..\..\eBcode\embobj\core\core;..\..\..\..\..\..\..\eBcode\embobj\core\exec\multitask;..\..\..\..\..\..\..\eBcode\embobj\plus\embenv;..\..\..\..\..\..\..\eBcode\embobj\plus\ipnet;..\..\..\..\..\..\..\eBcode\arch-arm\libs\services\embenv\api;..\..\..\..\..\..\..\eBcode\arch-arm\libs\midware\eventviewer\api;..\app_main;..\app_cfg;..\abslayer-cfg-stm32f4;..\..\..\..\..\..\..\eBcode\embobj\plus\ctrloop;..\..\..\..\..\..\..\eBcode\embobj\plus\comm-v2\icub;..\..\..\..\..\..\..\eBcode\embobj\plus\comm-v1\opcprot;..\..\..\..\..\..\..\eBcode\embobj\plus\comm-v2\transport;..\..\..\..\..\..\..\eBcode\embobj\plus\comm-v2\protocol\api;..\..\..\..\..\..\..\eBcode\robotconfig\v1\eprotocol;..\embenv_cfg\ems004like;..\..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\hal2\api
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg-stm32f4
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\embenv_cfg\ems004like\eApplication.sct
