# Keil uVision project eom-application-ipnet-ems4rd.uvprojx, settings and files
target mcbstm32f400 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: eom-appl-basic +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: HAL_USE_ARCH_ARM
  c misc: --c99
  c include: ..\..\cfg;..\app_extra;..\app_basic;..\..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\hal\api;..\..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\ipal\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\exec\multitask;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\ipnet;..\..\..\..\..\..\..\eBcode\arch-arm\libs\midware\eventviewer\api
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group application
    ../app_ipnet/: eom_applipnet_main.c eom_applipnet_specialise.c
  group abslayer-lib
    ../../../../../../../eBcode/arch-arm/libs/highlevel/abslayer/hal2/lib/: hal2.ems4rd.lib
    ../../../../../../../eBcode/arch-arm/libs/highlevel/abslayer/osal/lib/: osal.cm4.dbg.lib
    ../../../../../../../eBcode/arch-arm/libs/highlevel/abslayer/ipal/lib/: ipal.base.medium.cm4.lib
  group abslayer-cfg
    ../abslayer-cfg-stm32f4/: hal_startup_mpu_name_stm32f407ig.s hal_core_cfg.c ipal_cfg.c osal_cfg.c hal_core_cfg.h ipal_cfg.h osal_cfg.h
  group eo-core
    ../../../../../../../../../icub-firmware-shared/eth/embobj/core/core/: EOaction.c EOarray.c EoCommon.c EOconstarray.c EOconstvector.c EOdeque.c EOfifo.c EOfifoByte.c EOfifoWord.c EOlist.c EONmutex.c EONtask.c EONtheCallbackManager.c EONtheSystem.c EONtheTimerManager.c EOpacket.c EOsm.c EOtheErrorManager.c EOtheLEDpulser.c EOtheMemoryPool.c EOtimer.c EOumlsm.c EOvector.c EOVmutex.c EOVtask.c EOVtheCallbackManager.c EOVtheSystem.c EOVtheTimerManager.c
  group eo-mee
    ../../../../../../../../../icub-firmware-shared/eth/embobj/core/exec/multitask/: EOMmutex.c EOMtask.c EOMtheCallbackManager.c EOMtheSystem.c EOMtheTimerManager.c
  group eo-ipnet
    ../../../../../../../../../icub-firmware-shared/eth/embobj/plus/ipnet/: EOMtheIPnet.c EOsocket.c EOsocketDatagram.c EOVtheIPnet.c
  group eventviewer
    ../../../../../../../eBcode/arch-arm/libs/midware/eventviewer/src/: eventviewer.c
target ems4rd-zerooffset (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: eom-appl-ipnet +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1
  c define: HAL_IS_VERSION_2
  c include: ..\..\cfg-ems4rd;..\app_extra;..\app_basic;..\..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\hal2\api;..\..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\ipal\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\exec\multitask;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\ipnet;..\..\..\..\..\..\..\eBcode\arch-arm\libs\midware\eventviewer\api;..\embenv_cfg\ems004like
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 3.30.0
