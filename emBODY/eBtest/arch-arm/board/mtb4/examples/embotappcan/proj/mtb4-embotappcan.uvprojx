# Keil uVision project mtb4-embotappcan.uvprojx, settings and files
target mtb-app (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L433RCIx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: nucleo-hal +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32HAL_BOARD_MTB4 APPSLIM_RELOCATEVECTORTABLE APPSLIM_STM32HAL_TICK_SYSTICK
  c misc: --cpp11
  c include: ..\..\..\..\..\..\..\eBcode\arch-arm\libs\midware\eventviewer\api;..\..\..\..\..\..\..\eBcode\arch-arm\libs\lowlevel\stm32hal\api;..\..\..\..\..\..\..\eBcode\arch-arm\embot\common;..\..\..\..\..\..\..\eBcode\arch-arm\embot\app;..\..\..\..\..\..\..\eBcode\arch-arm\embot\i2h;..\..\..\..\..\..\..\eBcode\arch-arm\embot\hw;..\..\..\..\..\..\..\eBcode\arch-arm\embot\sys;..\..\..\..\..\..\..\eBcode\arch-arm\embot
  asm misc: --cpreproc
  asm include: ..\cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\mtb4-application.sct
  link misc: --diag_suppress=L6329
  group mbt4-app
    ../src/: main-application.cpp can_parser.cpp operations.c
  group stm32hal-mtb4
    ../../../../../../../eBcode/arch-arm/libs/lowlevel/stm32hal/lib/: stm32hal.mtb4.lib
    ../../../../../../../eBcode/arch-arm/libs/lowlevel/stm32hal/startup/: stm32hal.startup.mtb4.s
  group stm32hal-config
    ../cfg/: stm32hal_stg.h
  group embot
    ../../../../../../../eBcode/arch-arm/embot/common/: embot_common.cpp
    ../../../../../../../eBcode/arch-arm/embot/binary/: embot_binary.cpp
  group embot-hw
    ../../../../../../../eBcode/arch-arm/embot/hw/: embot_hw.cpp embot_hw_bsp.cpp embot_hw_sys.cpp embot_hw_led.cpp embot_hw_can.cpp
target mtb-app-0offset (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L433RCIx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.4.0
  cpu: as above
  output: nucleo-hal
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32HAL_BOARD_MTB4 APPSLIM_DONTRELOCATEVECTORTABLE APPSLIM_STM32HAL_TICK_SYSTICK
  c misc: --cpp11
  c include: ..\..\..\..\..\..\..\eBcode\arch-arm\libs\midware\eventviewer\api;..\..\..\..\..\..\..\eBcode\arch-arm\libs\lowlevel\stm32hal\api;..\..\..\..\..\..\..\eBcode\arch-arm\embot\common;..\..\..\..\..\..\..\eBcode\arch-arm\embot\binary;..\..\..\..\..\..\..\eBcode\arch-arm\embot\hw
  asm misc: --cpreproc
  asm include: ..\cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\mtb4-application0offset.sct
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 5.0.1
