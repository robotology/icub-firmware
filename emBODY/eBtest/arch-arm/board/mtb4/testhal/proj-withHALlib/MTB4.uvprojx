# Keil uVision project MTB4.uvprojx, settings and files
target mtb4-withHALfiles (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L443RCIx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: mtb4
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32HAL_BOARD_MTB4
  c misc: --cpp11
  c include: ..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\eBcode\arch-arm\libs\midware\eventviewer\api;..\..\..\..\..\..\eBcode\arch-arm\embobj\core\exec\multitask;..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core;..\..\..\..\..\..\eBcode\arch-arm\embot\common;..\..\..\..\..\..\eBcode\arch-arm\embot\app;..\..\..\..\..\..\eBcode\arch-arm\embot\i2h;..\..\..\..\..\..\eBcode\arch-arm\embot\hw;..\..\..\..\..\..\eBcode\arch-arm\embot\sys;..\..\..\..\..\..\eBcode\arch-arm\embot;..\..\..\..\..\..\eBcode\arch-arm\libs\lowlevel\stm32hal\api;..\..\..\..\..\..\eBcode\arch-arm\libs\lowlevel\stm32hal\src\board\mtb4\inc;..\..\..\..\..\..\eBcode\arch-arm\libs\lowlevel\stm32hal\src\stm32l4\inc
  asm misc: --cpreproc
  asm include: ..\cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  link misc: --diag_suppress=L6329
  group mtb4-app
    ../src/: main-application.cpp slim_retarget_io.c
  group stm32hal-config
    ../cfg/: stm32hal_stg.h
    ../src/: stm32hal.startup.mtb4.s startup_stm32l443xx.s
  group osal
    ../../../../../../eBcode/arch-arm/libs/highlevel/abslayer/osal/lib/: osal.cm4.dbg.lib
  group eventviewer
    ../../../../../../eBcode/arch-arm/libs/midware/eventviewer/src/: eventviewer.c
  group embobj-shared
    ../../../../../../../../icub-firmware-shared/eth/embobj/core/core/: EOaction.c EOarray.c EoCommon.c EOconstarray.c EOconstvector.c EOdeque.c EOfifo.c EOfifoByte.c EOfifoWord.c EOlist.c EOpacket.c EOsm.c EOtheErrorManager.c EOtheLEDpulser.c EOtheMemoryPool.c EOtimer.c EOumlsm.c EOvector.c EOVmutex.c EOVtask.c EOVtheCallbackManager.c EOVtheSystem.c EOVtheTimerManager.c
  group embobj-mee
    ../../../../../../eBcode/arch-arm/embobj/core/exec/multitask/: EOMtheTimerManager.c EOMtheCallbackManager.c EOMtask.c EOMmutex.c
  group embot
    ../../../../../../eBcode/arch-arm/embot/common/: embot_common.cpp
    ../../../../../../eBcode/arch-arm/embot/i2h/: embot_i2h.cpp
    ../../../../../../eBcode/arch-arm/embot/sys/: embot_sys.cpp embot_sys_Task.cpp embot_sys_theCallbackManager.cpp embot_sys_theJumper.cpp embot_sys_theScheduler.cpp embot_sys_theStorage.cpp embot_sys_theTimerManager.cpp embot_sys_Timer.cpp
    ../../../../../../eBcode/arch-arm/embot/hw/: embot_hw_can.cpp embot_hw.cpp embot_hw_sys.cpp embot_hw_FlashStorage.cpp
    ../../../../../../eBcode/arch-arm/embot/app/: embot_app_theApplication.cpp embot_app_theBootloader.cpp embot_app_theCANboardInfo.cpp embot_app_theCANservice.cpp embot_app_theLoop.cpp
  group hal-lib
    ../../../../../../eBcode/arch-arm/libs/lowlevel/stm32hal/lib/: stm32hal.mtb4.lib
    ../../../../../../eBcode/arch-arm/libs/lowlevel/stm32hal/src/board/mtb4/src/: stm32l4xx_it.c
target mtb4-withHALlib (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L443RCIx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.4.0
  cpu: as above
  output: mtb4
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32HAL_BOARD_MTB4
  c misc: --cpp11
  c include: as above
  asm misc: --cpreproc
  asm include: ..\cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 5.0.0
