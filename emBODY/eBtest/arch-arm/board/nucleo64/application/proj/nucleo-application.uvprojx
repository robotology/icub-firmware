# Keil uVision project nucleo-application.uvprojx, settings and files
target nucleo-app (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: nucleo-hal
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STM32HAL STM32HAL_BOARD_NUCLEO64
  c misc: --cpp11
  c include: ..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\eBcode\arch-arm\libs\midware\eventviewer\api;..\..\..\..\..\..\eBcode\arch-arm\embobj\core\exec\multitask;..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core;..\..\..\..\..\..\eBcode\arch-arm\libs\lowlevel\stm32hal\api;..\..\..\..\..\..\eBcode\arch-arm\embot\common;..\..\..\..\..\..\eBcode\arch-arm\embot\app;..\..\..\..\..\..\eBcode\arch-arm\embot\i2h;..\..\..\..\..\..\eBcode\arch-arm\embot\hw;..\..\..\..\..\..\eBcode\arch-arm\embot\sys;..\..\..\..\..\..\eBcode\arch-arm\embot
  asm misc: --cpreproc
  asm include: ..\cfg
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000020 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: .\nucleo-application.sct
  link misc: --diag_suppress=L6329
  group nucleo-app
    ../src/: main-application.cpp slim_retarget_io.c
  group stm32hal-nucleo
    ../../../../../../eBcode/arch-arm/libs/lowlevel/stm32hal/lib/: stm32hal.nucleo64.lib
    ../../../../../../eBcode/arch-arm/libs/lowlevel/stm32hal/startup/: stm32hal.startup.nucleo64.s
  group stm32hal-config
    ../cfg/: stm32hal_stg.h
  group osal
    ../../../../../../eBcode/arch-arm/libs/highlevel/abslayer/osal/lib/: osal.cm4.dbg.lib
  group eventviewer
    ../../../../../../eBcode/arch-arm/libs/midware/eventviewer/src/: eventviewer.c
  group embobj-shared
    ../../../../../../../../icub-firmware-shared/eth/embobj/core/core/: EOaction.c EOarray.c EoCommon.c EOconstarray.c EOconstvector.c EOdeque.c EOfifo.c EOfifoByte.c EOfifoWord.c EOlist.c EOpacket.c EOsm.c EOtheErrorManager.c EOtheLEDpulser.c EOtheMemoryPool.c EOtimer.c EOumlsm.c EOvector.c EOVmutex.c EOVtask.c EOVtheCallbackManager.c EOVtheSystem.c EOVtheTimerManager.c
  group embobj-mee
    ../../../../../../eBcode/arch-arm/embobj/core/exec/multitask/: EOMtheTimerManager.c EOMtheCallbackManager.c EOMtask.c EOMmutex.c
  group embot
    ../../../../../../eBcode/arch-arm/embot/common/: embot_common.cpp
    ../../../../../../eBcode/arch-arm/embot/i2h/: embot_i2h.cpp
    ../../../../../../eBcode/arch-arm/embot/sys/: embot_sys.cpp embot_sys_Task.cpp embot_sys_theCallbackManager.cpp embot_sys_theJumper.cpp embot_sys_theScheduler.cpp embot_sys_theStorage.cpp embot_sys_theTimerManager.cpp embot_sys_Timer.cpp
    ../../../../../../eBcode/arch-arm/embot/hw/: embot_hw.cpp embot_hw_FlashStorage.cpp
    ../../../../../../eBcode/arch-arm/embot/app/: embot_app_theApplication.cpp embot_app_theBootloader.cpp embot_app_theCANboardInfo.cpp embot_app_theCANservice.cpp embot_app_theLoop.cpp
software components: CMSIS:CORE 4.1.0
