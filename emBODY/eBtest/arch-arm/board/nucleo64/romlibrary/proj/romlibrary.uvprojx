# Keil uVision project romlibrary.uvprojx, settings and files
target nucleo-romlibrary (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: nucleo-romlibrary +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=1
  c misc: --c99
  c include: ..\api
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000020 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: .\nucleo-romlibrary.sct
  link misc: --entry romlib_entrypoint --symdefs ..\lib\romlibrary.nucleo.obj
  group lib
    ../src/: romlibrary.c
software components: CMSIS:CORE 4.1.0
