# Keil uVision project hal.stm32f4-lib-hlplus.uvprojx, settings and files
target hal.mcbstm32f400 (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: hal.stm32f4.mcbstm32f400 (library)
  AfterMake: cmd.exe /C copy .\Obj\hal.stm32f4.mcbstm32f400.lib ..\hal-lib\hal.stm32f4.mcbstm32f400.lib
  c flags: Optim=1 OneElfS=1
  c define: HAL_BOARD_MCBSTM32F400 HL_USE_BRD_MCBSTM32_F400 HL_CFG_PLUS_TARGET_BY_FILE
  c misc: --c99
  c include: ..\..\hal\hal-api;..\..\hal\hal-src\core;..\..\hal\hal-src\brdcfg;..\..\hal\hal-src\extra\chips;..\..\hal\hal-src\extra\devices;..\..\hal\hal-src\extra\extbrds;..\..\hal\hal-src\extra\periphs;..\..\hal\hal-src\extra\utilities;..\..\..\..\..\..\..\..\eBcode\arch-arm\libs\midware\eventviewer\api;..\..\..\..\..\..\..\..\eBcode\arch-arm\libs\abslayer\ipal\api;..\app-test\stm32f4;..\..\..\..\..\..\..\..\eBcode\arch-arm\libs\midware\hl-plus\api;..\..\..\..\..\..\..\..\eBcode\arch-arm\libs\lowlevel\hl-core\cmsis\api;..\..\..\..\..\..\..\..\eBcode\arch-arm\libs\lowlevel\hl-core\stm32f4\api
  asm misc: --cpreproc
  asm include: ..\hal-cfg
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group hl-plus-cfg
    ../hal-src/brdcfg/: hl_cfg_plus_modules.h hl_cfg_plus_target.h hl_cfg_plus_board_stm32f4.c hl_cfg_plus_advancedcmsis.c
  group hl-plus-wrappers
    ../../../../../../../../eBcode/arch-arm/libs/midware/hl-plus/src/wrappers/: hl_wrap_adc.c hl_wrap_bkp.c hl_wrap_can.c hl_wrap_cec.c hl_wrap_crc.c hl_wrap_cryp.c hl_wrap_cryp_aes.c hl_wrap_cryp_des.c hl_wrap_cryp_tdes.c hl_wrap_dac.c hl_wrap_dbgmcu.c hl_wrap_dcmi.c hl_wrap_dma.c hl_wrap_exti.c hl_wrap_flash.c hl_wrap_fsmc.c hl_wrap_gpio.c hl_wrap_hash.c hl_wrap_hash_md5.c hl_wrap_hash_sha1.c hl_wrap_i2c.c hl_wrap_iwdg.c hl_wrap_misc.c hl_wrap_pwr.c hl_wrap_rcc.c hl_wrap_rtc.c hl_wrap_sdio.c hl_wrap_spi.c hl_wrap_syscfg.c hl_wrap_system.c hl_wrap_tim.c hl_wrap_usart.c hl_wrap_wwdg.c
  group hal-brdcfg
    ../../hal/hal-src/brdcfg/: hal_brdcfg.c
  group hal-core
    ../../hal/hal-src/core/: hal_base.c hal_core.c hal_cpu.c hal_flash.c hal_heap.c hal_middleware_interface.c hal_sys.c
  group hal-extra-chips
    ../../hal/hal-src/extra/chips/: hal_chip_generic_ethtransceiver.c hal_chip_micrel_ks8893.c hal_chip_st_l3g4200d.c hal_chip_st_lis3dh.c hal_chip_xx_eeprom.c
  group hal-extra-devices
    ../../hal/hal-src/extra/devices/: hal_device_accelerometer.c hal_device_cantransceiver.c hal_device_display.c hal_device_eeprom.c hal_device_encoder.c hal_device_ethtransceiver.c hal_device_gyroscope.c hal_device_led.c hal_device_mux.c hal_device_switch.c hal_device_termometer.c hal_device_eeprom_dummy.c
    ../hal-src/extra/devices/: hal_device_encoder_fake.c
  group hal-extra-extbrds
    ../../hal/hal-src/extra/extbrds/: hal_extbrd_keil_mcbqvga.c
  group hal-extra-periphs
    ../../hal/hal-src/extra/periphs/: hal_periph_can.hl.only.c hal_periph_crc.c hal_periph_dma.c hal_periph_eth.hl.c hal_periph_gpio.c hal_periph_i2c.c hal_periph_spi.c hal_periph_timer.c hal_periph_trace.c hal_periph_uniqueid.c hal_periph_watchdog.c
    ../hal-src/extra/periphs/: hal_periph_spi_minimal.c
  group hal-extra-utilities
    ../../hal/hal-src/extra/utilities/: hal_utility_bits.c hal_utility_crc07.c hal_utility_crc16.c hal_utility_crc32.c hal_utility_fifo.c
  group hl-plus-utils
    ../../../../../../../../eBcode/arch-arm/libs/midware/hl-plus/src/utils/: hl_bits.c hl_can.c hl_common.c hl_eth.c hl_ethtrans.c hl_fifo.c hl_gpio.c hl_i2c.c hl_sys.c hl_timer.c hl_can_comm.c hl_spi.c
  group hl-plus-chips
    ../../../../../../../../eBcode/arch-arm/libs/midware/hl-plus/src/chips/: hl_chip_micrel_ks8893.c hl_chip_st_l3g4200d.c hl_chip_st_lis3x.c hl_chip_xx_eeprom.c hl_chip_xx_ethphy.c
target hal-em4rd (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: as above
  output: hal_ems4rd_beta (library)
  AfterMake: cmd.exe /C copy .\Obj\hal_ems4rd_beta.lib ..\hal-lib\hal.ems4rd.beta.lib
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: HAL_BOARD_EMS4RD HL_USE_BRD_EMS4RD HL_CFG_PLUS_TARGET_BY_FILE
  c include: as above
  asm misc: --cpreproc
  asm include: ..\hal-cfg
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target hal-ems4rd-ethdbg (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: as above
  output: hal_ems4rd_beta_ethdbg (library)
  AfterMake: cmd.exe /C copy .\Obj\hal_ems4rd_beta_ethdbg.lib ..\hal-lib\hal.ems4rd.beta.ethdbg.lib
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1
  c define: HAL_BOARD_EMS4RD HL_USE_BRD_EMS4RD HL_CFG_PLUS_TARGET_BY_FILE EMS4RD_ETHDBG
  c include: as above
  asm misc: --cpreproc
  asm include: ..\hal-cfg
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 3.30.0
