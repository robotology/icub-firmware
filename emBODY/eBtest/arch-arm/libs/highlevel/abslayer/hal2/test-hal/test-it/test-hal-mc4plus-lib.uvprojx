# Keil uVision project test-hal-mc4plus-lib.uvprojx, settings and files
target mc4plus (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: blinky
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HAL_USE_LIB
  c include: ..\..\..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\hal2\api;..\..\..\..\..\..\..\..\eBcode\arch-arm\libs\midware\eventviewer\api;..\..\..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\ipal\api;..\app-test\stm32f4;..\..\..\..\..\..\..\..\eBcode\arch-arm\libs\lowlevel\hl-core\stm32f4\api;..\..\..\..\..\..\..\..\eBcode\arch-arm\libs\midware\hl-plus\api
  asm misc: --cpreproc
  asm include: ..\hal-cfg
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ../app-test/: core-plus-mc4plus.c pid.c
  group hal-cfg
    ../hal-cfg/: hal_core_cfg.h hal_core_cfg.c
  group hal-startup
    ../../../../../../../../eBcode/arch-arm/libs/highlevel/abslayer/hal2/stg/: hal_startup_mpu_name_stm32f407ig.template.s
  group ipal
    ../app-test/: ipal_cfg.h ipal_cfg.c
    ../../../../../../../../eBcode/arch-arm/libs/highlevel/abslayer/ipal/lib/: ipal.base.medium.cm4.lib
  group eviewer
    ../../../../../../../../eBcode/arch-arm/libs/midware/eventviewer/src/: eventviewer.c
  group hal2
    ../../../../../../../../eBcode/arch-arm/libs/highlevel/abslayer/hal2/lib/: hal2.mc4plus.lib hal2.mc4plus.ethdbg.lib
software components: CMSIS:CORE 3.30.0
