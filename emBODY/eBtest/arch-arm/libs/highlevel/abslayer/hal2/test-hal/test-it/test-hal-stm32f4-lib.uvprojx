# Keil uVision project test-hal-stm32f4-lib.uvprojx, settings and files
target mcbstm32f400 (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: blinky
  c flags: Optim=1 OneElfS=1
  c define: HAL_BOARD_MCBSTM32F400 HL_USE_BRD_MCBSTM32_F400 HL_CFG_PLUS_TARGET_BY_FILE
  c misc: --c99
  c include: ..\..\hal\hal-api;..\..\..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\hal2\src\core;..\..\..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\hal2\src\brdcfg;..\..\..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\hal2\src\extra\chips;..\..\..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\hal2\src\extra\devices;..\..\..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\hal2\src\extra\extbrds;..\..\..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\hal2\src\extra\periphs;..\..\..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\hal2\src\extra\utilities;..\..\..\..\..\..\..\..\eBcode\arch-arm\libs\midware\eventviewer\api;..\..\..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\ipal\api;..\app-test\stm32f4;..\..\..\..\..\..\..\..\eBcode\arch-arm\libs\midware\hl-plus\api;..\..\..\..\..\..\..\..\eBcode\arch-arm\libs\lowlevel\hl-core\cmsis\api;..\..\..\..\..\..\..\..\eBcode\arch-arm\libs\lowlevel\hl-core\stm32f4\api
  asm misc: --cpreproc
  asm include: ..\hal-cfg
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ../app-test/: core-plus-stm32fx.c
  group hal-cfg
    ../hal-cfg/: hal_core_cfg.h hal_core_cfg.c
  group hal-startup
    ../../../../../../../../eBcode/arch-arm/libs/highlevel/abslayer/hal2/stg/: hal_startup_mpu_name_stm32f407ig.template.s
  group ipal
    ../app-test/: ipal_cfg.h ipal_cfg.c
    ../../../../../../../../eBcode/arch-arm/libs/highlevel/abslayer/ipal/lib/: ipal.base.medium.lib
  group eviewer
    ../../../../../../../../eBcode/arch-arm/libs/midware/eventviewer/src/: eventviewer.c
  group hal2
    ../../../../../../../../eBcode/arch-arm/libs/highlevel/abslayer/hal2/lib/: hal2.ems4rd.lib hal2.mc4plus.lib hal2.ems4rd.ethdbg.lib hal2.mc4plus.ethdbg.lib
target ems4rd (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: as above
  output: blinky
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: HAL_USE_LIB
  c include: ..\..\..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\hal2\api;..\..\..\..\..\..\..\..\eBcode\arch-arm\libs\midware\eventviewer\api;..\..\..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\ipal\api;..\app-test\stm32f4
  asm misc: --cpreproc
  asm include: ..\hal-cfg
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target mc4plus (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: as above
  output: blinky
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: HAL_USE_LIB
  c include: as above
  asm misc: --cpreproc
  asm include: ..\hal-cfg
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 3.30.0
