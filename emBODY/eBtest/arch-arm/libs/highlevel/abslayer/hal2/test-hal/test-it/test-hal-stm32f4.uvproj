# Keil uVision project test-hal-stm32f4.uvproj, settings and files
target mcbstm32f400 (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: blinky
  c flags: Optim=1 OneElfS=1
  c define: HAL_BOARD_MCBSTM32F400 HL_USE_BRD_MCBSTM32_F400 HL_CFG_PLUS_TARGET_BY_FILE
  c misc: --c99
  c include: ..\..\hal\hal-api;..\..\..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\hal2\src\core;..\..\..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\hal2\src\brdcfg;..\..\..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\hal2\src\extra\chips;..\..\..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\hal2\src\extra\devices;..\..\..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\hal2\src\extra\extbrds;..\..\..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\hal2\src\extra\periphs;..\..\..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\hal2\src\extra\utilities;..\..\..\..\..\..\..\..\eBcode\arch-arm\libs\midware\eventviewer\api;..\..\..\..\..\..\..\..\eBcode\arch-arm\libs\abslayer\ipal\api;..\app-test\stm32f4;..\..\..\..\..\..\..\..\eBcode\arch-arm\libs\midware\hl-plus\api;..\..\..\..\..\..\..\..\eBcode\arch-arm\libs\lowlevel\hl-core\cmsis\api;..\..\..\..\..\..\..\..\eBcode\arch-arm\libs\lowlevel\hl-core\stm32f4\api
  asm misc: --cpreproc
  asm include: ..\hal-cfg
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ../app-test/: core-plus-stm32fx.c
  group hal-cfg
    ../hal-cfg/: hal_core_cfg.h hal_core_cfg.c
  group hal-startup
    ../../../../../../../../eBcode/arch-arm/libs/highlevel/abslayer/hal2/stg/: hal_startup_cpu_nam_stm32f407.s
  group hal-brdcfg
    ../../../../../../../../eBcode/arch-arm/libs/highlevel/abslayer/hal2/src/brdcfg/: hal_brdcfg_modules.h hal_brdcfg.c
  group hal-core
    ../../../../../../../../eBcode/arch-arm/libs/highlevel/abslayer/hal2/src/core/: hal_base.c hal_core.c hal_mpu.c hal_flash.c hal_heap.c hal_middleware_interface.c hal_sys.c
  group hal-extra-devices
    ../../../../../../../../eBcode/arch-arm/libs/highlevel/abslayer/hal2/src/extra/devices/: hal_accelerometer.c hal_cantransceiver.c hal_eeprom.c hal_encoder.c hal_ethtransceiver.c hal_gyroscope.c hal_led.c hal_mux.c hal_switch.c hal_termometer.c
  group hal-extra-periphs
    ../../../../../../../../eBcode/arch-arm/libs/highlevel/abslayer/hal2/src/extra/periphs/: hal_can.c hal_eth.c hal_gpio.c hal_i2c.c hal_timer.c hal_trace.c hal_uniqueid.c hal_watchdog.c hal_spi.c
  group ipal
    ../app-test/: ipal_cfg.h ipal_cfg.c
    ../../../../../../../../eBcode/arch-arm/libs/abslayer/ipal/lib/: ipal.base.medium.lib
  group eviewer
    ../../../../../../../../eBcode/arch-arm/libs/midware/eventviewer/src/: eventviewer.c
  group hl-plus-cfg
    ../../../../../../../../eBcode/arch-arm/libs/highlevel/abslayer/hal2/src/brdcfg/: hl_cfg_plus_target.h hl_cfg_plus_modules.h
  group hl-plus-wrappers
    ../../../../../../../../eBcode/arch-arm/libs/midware/hl-plus/src/wrappers/: hl_wrap_adc.c hl_wrap_bkp.c hl_wrap_can.c hl_wrap_cec.c hl_wrap_crc.c hl_wrap_cryp.c hl_wrap_cryp_aes.c hl_wrap_cryp_des.c hl_wrap_cryp_tdes.c hl_wrap_dac.c hl_wrap_dbgmcu.c hl_wrap_dcmi.c hl_wrap_dma.c hl_wrap_exti.c hl_wrap_flash.c hl_wrap_fsmc.c hl_wrap_gpio.c hl_wrap_hash.c hl_wrap_hash_md5.c hl_wrap_hash_sha1.c hl_wrap_i2c.c hl_wrap_iwdg.c hl_wrap_misc.c hl_wrap_pwr.c hl_wrap_rcc.c hl_wrap_rtc.c hl_wrap_sdio.c hl_wrap_spi.c hl_wrap_syscfg.c hl_wrap_system.c hl_wrap_tim.c hl_wrap_usart.c hl_wrap_wwdg.c
  group hl-plus-utils
    ../../../../../../../../eBcode/arch-arm/libs/midware/hl-plus/src/utils/: hl_bits.c hl_can.c hl_common.c hl_eth.c hl_ethtrans.c hl_fifo.c hl_gpio.c hl_i2c.c hl_sys.c hl_timer.c hl_can_comm.c hl_spi.c
  group hl-plus-chips
    ../../../../../../../../eBcode/arch-arm/libs/midware/hl-plus/src/chips/: hl_chip_micrel_ks8893.c hl_chip_st_l3g4200d.c hl_chip_st_lis3x.c hl_chip_xx_eeprom.c hl_chip_xx_ethphy.c
target ems4rD (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: as above
  output: blinky
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=2
  c define: HAL_BOARD_EMS4RD HL_USE_BRD_EMS4RD HL_CFG_PLUS_TARGET_BY_FILE EMS4RD_ETHDBG
  c misc: --c99
  c include: ..\..\..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\hal2\api;..\..\..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\hal2\src\core;..\..\..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\hal2\src\brdcfg;..\..\..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\hal2\src\extra\chips;..\..\..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\hal2\src\extra\devices;..\..\..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\hal2\src\extra\extbrds;..\..\..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\hal2\src\extra\periphs;..\..\..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\hal2\src\extra\utilities;..\..\..\..\..\..\..\..\eBcode\arch-arm\libs\midware\eventviewer\api;..\..\..\..\..\..\..\..\eBcode\arch-arm\libs\abslayer\ipal\api;..\app-test\stm32f4;..\..\..\..\..\..\..\..\eBcode\arch-arm\libs\midware\hl-plus\api;..\..\..\..\..\..\..\..\eBcode\arch-arm\libs\lowlevel\hl-core\cmsis\api;..\..\..\..\..\..\..\..\eBcode\arch-arm\libs\lowlevel\hl-core\stm32f4\api
  asm misc: --cpreproc
  asm include: ..\hal-cfg
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
