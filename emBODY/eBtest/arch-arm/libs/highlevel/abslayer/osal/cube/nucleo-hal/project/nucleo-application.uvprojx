# Keil uVision project nucleo-application.uvprojx, settings and files
target nucleo-bl (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: nucleo-hal
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER STM32L476xx ACEMORISED
  c misc: --cpp11
  c include: ../Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include;..\..\..\..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\..\..\..\eBcode\arch-arm\libs\midware\eventviewer\api;..\..\..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core;..\..\..\..\..\..\..\..\..\eBcode\arch-arm\embobj\core\exec\multitask;..\..\..\embot;..\src-plus
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000020 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: .\nucleo-application.sct
  link misc: --diag_suppress=L6329
  group nucleo-application
    ../src-plus/: main-application.cpp slim_retarget_io.c
  group nucleo-cmsis
    ../Src/: system_stm32l4xx.c
    ./: startup_stm32l476xx.s
  group nucleo-hal
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_flash_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_rcc.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_tim.c stm32l4xx_hal_uart.c stm32l4xx_hal_pwr.c stm32l4xx_hal_flash.c
  group nucleo-hal-bsp
    ../Src/: gpio.c usart.c stm32l4xx_hal_msp.c
  group osal
    ../../../../../../../../../eBcode/arch-arm/libs/highlevel/abslayer/osal/lib/: osal.cm4.dbg.lib
  group eventviewer
    ../../../../../../../../../eBcode/arch-arm/libs/midware/eventviewer/src/: eventviewer.c
  group embot
    ../../../embot/: embot_common.cpp embot_i2h.cpp embot_sys.cpp embot_sys_Task.cpp embot_sys_theCallbackManager.cpp embot_sys_theJumper.cpp embot_sys_theScheduler.cpp embot_sys_theStorage.cpp embot_sys_theTimerManager.cpp embot_sys_Timer.cpp embot_hw_FlashStorage.cpp embot_hw.cpp embot_app_theBootloader.cpp embot_app_theCANboardInfo.cpp embot_app_theApplication.cpp embot_app_theLoop.cpp embot_app_theCANservice.cpp
  group embobj-shared
    ../../../../../../../../../../../icub-firmware-shared/eth/embobj/core/core/: EOaction.c EOarray.c EoCommon.c EOconstarray.c EOconstvector.c EOdeque.c EOfifo.c EOfifoByte.c EOfifoWord.c EOlist.c EOpacket.c EOsm.c EOtheErrorManager.c EOtheLEDpulser.c EOtheMemoryPool.c EOtimer.c EOumlsm.c EOvector.c EOVmutex.c EOVtask.c EOVtheCallbackManager.c EOVtheSystem.c EOVtheTimerManager.c
  group embobj-mee
    ../../../../../../../../../eBcode/arch-arm/embobj/core/exec/multitask/: EOMtheTimerManager.c EOMtheCallbackManager.c EOMtask.c EOMmutex.c
  group bsp-nucleo
    ../src-plus/: bsp_nucleo.c
software components: CMSIS:CORE 4.1.0
