# Keil uVision project test-osal-lib.uvprojx, settings and files
target mcbstm32f400-c (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Blinky
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx HL_USE_BRD_MCBSTM32F400
  c include: ..\cmsis-cfg;..\..\..\..\..\..\..\eBcode\arch-arm\libs\lowlevel\hl-core\cmsis\api;..\..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\osal\api;..\..\..\..\lowlevel\hl-core-tests\app-test\cmsis;..\..\..\..\midware\hl-plus-tests\app-test\core;..\..\..\..\..\..\..\eBcode\arch-arm\libs\midware\eventviewer\api
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group application
    ../app-test/: blinky-stm32fx.c blinky-stm32fx-cpp.cpp test-class.cpp test-singleton.cpp test-namespaces.cpp
    ../../../../midware/hl-plus-tests/app-test/core/: board.c
  group cmsis
    ../../../../../../../eBcode/arch-arm/libs/lowlevel/hl-core/cmsis/src/: system_stm32f4xx.c
  group cmsis-config
    ../app-test/: startup_stm32f4xx.s
  group osal-cfg
    ../osal-cfg/: osal_cfg.c osal_cfg.h
  group eventviewer
    ../../../../../../../eBcode/arch-arm/libs/midware/eventviewer/src/: eventviewer.c
  group osal
    ../../../../../../../eBcode/arch-arm/libs/highlevel/abslayer/osal/lib/: osal.cm4.dbg.lib
target mcbstm32f400-cpp11 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: as above
  output: Blinky
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx HL_USE_BRD_MCBSTM32F400
  c misc: -cpp11
  c include: ..\cmsis-cfg;..\..\..\..\..\..\..\eBcode\arch-arm\libs\lowlevel\hl-core\cmsis\api;..\..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\osal\api;..\..\..\..\lowlevel\hl-core-tests\app-test\cmsis;..\..\..\..\midware\hl-plus-tests\app-test\core;..\..\..\..\..\..\..\eBcode\arch-arm\libs\midware\eventviewer\api;..\app-test
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 3.30.0
