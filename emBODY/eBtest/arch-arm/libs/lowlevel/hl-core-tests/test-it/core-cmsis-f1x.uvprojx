# Keil uVision project core-cmsis-f1x.uvprojx, settings and files
target mcbstm32 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: cmsis
  c flags: Optim=1 uC99=1
  c define: STM32F10X_MD HL_USE_BRD_MCBSTM32
  c include: ..\cmsis-cfg;..\..\..\..\..\..\eBcode\arch-arm\libs\lowlevel\hl-core\cmsis\api
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group application
    ../app-test/cmsis/: blinky-stm32fx.c board.c systickservices.c
  group cmsis-cfg
    ../cmsis-cfg/: startup_stm32f10x_cl.s startup_stm32f10x_md.s
  group cmsis
    ../../../../../../eBcode/arch-arm/libs/lowlevel/hl-core/cmsis/src/: system_stm32f10x.c
target mcbstm32c (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: cmsis
  c flags: Optim=1 uC99=1
  c define: STM32F10X_CL HL_USE_BRD_MCBSTM32C
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
target ems001 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: cmsis
  c flags: Optim=1 uC99=1
  c define: STM32F10X_CL HL_USE_BRD_EMS001
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
software components: CMSIS:CORE 3.30.0
