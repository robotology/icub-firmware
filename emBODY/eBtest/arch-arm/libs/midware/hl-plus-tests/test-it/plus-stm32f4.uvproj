# Keil uVision project plus-stm32f4.uvproj, settings and files
target mcbstm32f400 (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: plus-stm32f1
  c flags: Optim=1 OneElfS=1
  c define: HL_CFG_PLUS_TARGET_BY_FILE HL_USE_BRD_MCBSTM32_F400
  c misc: --c99
  c include: ..\hl-plus-stm32f4-cfg;..\..\..\..\..\..\eBcode\arch-arm\libs\midware\hl-plus\api;..\..\..\..\..\..\eBcode\arch-arm\libs\midware\hl-plus\src\chips;..\..\..\..\..\..\eBcode\arch-arm\libs\midware\hl-plus\src\utils
  asm define: HL_CFG_PLUS_TARGET_BY_FILE
  asm misc: --cpreproc
  asm include: ..\hl-plus-stm32f4-cfg
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group application
    ../app-test/hl/: blinky-stm32f1-stm32fx.c board.c systickservices.c
  group hl-plus-cfg
    ../hl-plus-stm32f4-cfg/: hl_cfg_plus_target.h hl_cfg_plus_modules.h hl_cfg_plus_board_stm32f4.c hl_cfg_plus_advancedcmsis.c hl_cfg_plus_heapstack.h
  group hl-plus-startup
    ../hl-plus-stm32f4-cfg/: hl_startup_stm32f407.s
  group hl-plus-wrappers
    ../../../../../../eBcode/arch-arm/libs/midware/hl-plus/src/wrappers/: hl_wrap_adc.c hl_wrap_bkp.c hl_wrap_can.c hl_wrap_cec.c hl_wrap_crc.c hl_wrap_cryp.c hl_wrap_cryp_aes.c hl_wrap_cryp_des.c hl_wrap_cryp_tdes.c hl_wrap_dac.c hl_wrap_dbgmcu.c hl_wrap_dcmi.c hl_wrap_dma.c hl_wrap_exti.c hl_wrap_flash.c hl_wrap_fsmc.c hl_wrap_gpio.c hl_wrap_hash.c hl_wrap_hash_md5.c hl_wrap_hash_sha1.c hl_wrap_i2c.c hl_wrap_iwdg.c hl_wrap_misc.c hl_wrap_pwr.c hl_wrap_rcc.c hl_wrap_rtc.c hl_wrap_sdio.c hl_wrap_spi.c hl_wrap_syscfg.c hl_wrap_system.c hl_wrap_tim.c hl_wrap_usart.c hl_wrap_wwdg.c
  group hl-plus-utils
    ../../../../../../eBcode/arch-arm/libs/midware/hl-plus/src/utils/: hl_bits.c hl_can.c hl_common.c hl_eth.c hl_ethtrans.c hl_fifo.c hl_gpio.c hl_i2c.c hl_sys.c hl_timer.c
  group hl-plus-chips
    ../../../../../../eBcode/arch-arm/libs/midware/hl-plus/src/chips/: hl_chip_micrel_ks8893.c hl_chip_st_l3g4200d.c hl_chip_st_lis3x.c hl_chip_xx_eeprom.c hl_chip_xx_ethphy.c
target ems004 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: plus-stm32f1
  c flags: Optim=1 OneElfS=1
  c define: HL_CFG_PLUS_TARGET_BY_FILE HL_USE_BRD_EMS004
  c misc: --c99
  c include: ..\..\..\..\..\..\..\eBcode\arch-arm\libs\midware\hl\plus\api;..\..\..\..\..\..\..\eBcode\arch-arm\libs\midware\hl\plus\src\utils;..\..\..\..\..\..\..\eBcode\arch-arm\libs\midware\hl\plus\src\chips;..\hl-plus-stm32f4-cfg
  asm misc: --cpreproc
  asm include: ..\hl-plus-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
