# Keil uVision project oosiit-full.uvprojx, settings and files
target mcbstm32 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD HL_USE_BRD_MCBSTM32_C __CORTEX_M3  OOSIIT_USE_TIMEGET_UNDER_SVC
  c include: ..\cmsis-cfg;..\..\..\..\..\..\eBcode\arch-arm\libs\midware\oosiit\api;..\..\..\..\..\..\eBcode\arch-arm\libs\midware\oosiit\src\cmsis-rtx-modified\cm;..\..\..\..\..\..\eBcode\arch-arm\libs\midware\oosiit\src\others;..\..\..\..\..\..\eBcode\arch-arm\libs\midware\eventviewer\api;..\..\..\..\..\..\eBcode\arch-arm\libs\midware\eventviewer;..\..\..\..\..\..\eBcode\arch-arm\libs\lowlevel\hl-core\cmsis\api;..\..\..\lowlevel\hl-core-tests\app-test\cmsis
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group application
    ../app-test/: blinky-stm32fx.c adv-tests-stm32fx.c
    ../../../lowlevel/hl-core-tests/app-test/cmsis/: board.c
  group cmsis
    ../../../../../../eBcode/arch-arm/libs/lowlevel/hl-core/cmsis/src/: system_stm32f4xx.c system_stm32f10x.c
  group cmsis-config
    ../app-test/: startup_stm32f10x_md.s startup_stm32f10x_cl.s startup_stm32f4xx.s
  group oosiit-cfg
    ../oosiit-cfg/: oosiit_cfg.h oosiit_cfg.c
  group cmsis-rtx-src-modified
    ../../../../../../eBcode/arch-arm/libs/midware/oosiit/src/cmsis-rtx-modified/cm/: rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Memory.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
  group cmsis-rtx-cfg-modified
    ../../../../../../eBcode/arch-arm/libs/midware/oosiit/src/cmsis-rtx-modified/cm/: HAL_CM.c HAL_CM3.c HAL_CM4.c SVC_Table.s
  group others
    ../../../../../../eBcode/arch-arm/libs/midware/oosiit/src/others/: oosiit.c oosiit_storage.c rt_iit_AdvTimer.c rt_iit_changes.c rt_iit_memory.c
  group eventviewer
    ../../../../../../eBcode/arch-arm/libs/midware/eventviewer/src/: eventviewer.c
target mcbstm32c (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: HL_USE_BRD_MCBSTM32_C __CORTEX_M3  STM32F10X_CL OOSIIT_USE_TIMEGET_UNDER_SVC
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
target mcbstm32c-dbg (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: HL_USE_BRD_MCBSTM32_C __CORTEX_M3  STM32F10X_CL OOSIIT_DBG_ENABLE_ALL OOSIIT_USE_TIMEGET_UNDER_SVC
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
target mcbstm32f400 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Blinky
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx HL_USE_BRD_MCBSTM32F400 __CORTEX_M4F __FPU_PRESENT=1 OOSIIT_USE_TIMEGET_UNDER_SVC
  c misc: --diag_suppress 3731
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target mcbstm32f400-dbg (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx HL_USE_BRD_MCBSTM32_F400 __CORTEX_M4  __FPU_PRESENT OOSIIT_USE_TIMEGET_UNDER_SVC OOSIIT_DBG_ENABLE_ALL
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 3.30.0
